Properties of the parts of a building model (IFC4), part 4 of 5

# IfcPipeFitting: Sleeve:LX 11 (261)
Name (Sleeve:LX 11:...) | Elevation from Level (mm) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1143609 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1143616 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1143617 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1143624 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1143625 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1143632 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1143633 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1153947 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1153963 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1153969 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1153975 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1153981 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1153987 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1153993 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1154170 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1154176 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1154182 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1154188 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1154194 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1154200 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1154206 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1154212 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1154218 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1160548 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1160549 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1160566 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1160567 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1160574 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1160575 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1160582 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1160583 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1160590 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1160591 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1160598 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160599 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160606 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160607 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160614 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160615 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160622 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160623 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1160630 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160631 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160638 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160639 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160646 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160647 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160654 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160655 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1160662 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1160663 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1160670 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1160671 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1173712 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1173713 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1173718 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1173719 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1173724 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1173725 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1173730 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1173731 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1173736 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1173737 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1197118 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1197119 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1197131 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1197132 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1201062 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1201063 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1201064 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1201305 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1201306 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1201307 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1201455 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1201456 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1201457 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1201549 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1201550 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1201551 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1204904 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1204905 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1204906 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1207305 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1207306 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1207307 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1211084 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1211085 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1211086 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1211092 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211093 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1211094 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1211100 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211101 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211102 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211108 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1211109 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1211110 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211116 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1211117 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211118 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211124 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1211125 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211126 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1211347 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1211348 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211349 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211537 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1211538 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1211539 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1211629 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1211630 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1211637 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1211638 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212063 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212064 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212365 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212366 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1212367 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212373 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212374 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1212375 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212381 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212382 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212383 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212389 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212390 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1212391 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212397 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212398 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212399 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212405 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212406 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212407 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212413 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212414 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1212415 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212421 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212422 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212423 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212429 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212430 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212431 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212791 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212792 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212793 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1212799 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212800 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1212801 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212915 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212916 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1212917 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212993 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1212994 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1212995 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213089 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213090 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1213091 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213224 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1213323 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1213441 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1213570 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1213598 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213608 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1213618 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1213628 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213638 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1213648 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1213752 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213781 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1213782 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1213783 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1213789 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213791 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1213797 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1213798 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1213799 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1213805 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1213806 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1213807 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1279233 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1279234 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1279385 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1279386 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1281988 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1281989 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1281994 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1281995 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1284702 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1284703 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1284708 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1284709 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1284714 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1284715 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1284721 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1327809 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1327810 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1357840 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1395637 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1405585 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1405637 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1405759 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1577324 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1577326 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1597064 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1597065 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1597066 | 51 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1609883 | 50 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1688802 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1688803 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1688804 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26

# IfcPipeFitting: Sleeve:RX 11 (70)
In: Level 1
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: RX 11; Manufacturer: REHAU; Model: RX 11; REHAU Info: 14.02.2024-420668-420668; Type Name: RX 11
Type - Materials and Finishes - Mat. Error: Error; Mat. Sleeve: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Sleeve:RX 11; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: RX 11; T1: Sleeve DN; Type: RX 11; Type Id: 1027700
Constraints - Elevation from Level: 0 mm; Level: Level 1; Moves With Nearby Elements: no
Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2; L1: 53 mm
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:RX 11:...) | DN1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1119125 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1119126 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1119133 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1119134 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1119141 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1119142 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1119149 | 100 | 0.000193178 | REHAU Compression sleeve, SDR 11 RX 125 x 11.4 | 4007360537012 | 12352291002 | 5696 | https://oxomi.com/p/3000126/datasheet/-/12352291002 | 1.597
1119150 | 100 | 0.000193178 | REHAU Compression sleeve, SDR 11 RX 125 x 11.4 | 4007360537012 | 12352291002 | 5696 | https://oxomi.com/p/3000126/datasheet/-/12352291002 | 1.597
1119165 | 125 | 0.000289995 | REHAU Compression sleeve, SDR 11 RX 160 x 14.6 | 4007360537029 | 12343241002 | 5698 | https://oxomi.com/p/3000126/datasheet/-/12343241002 | 2.45
1119166 | 125 | 0.000289995 | REHAU Compression sleeve, SDR 11 RX 160 x 14.6 | 4007360537029 | 12343241002 | 5698 | https://oxomi.com/p/3000126/datasheet/-/12343241002 | 2.45
1154224 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1154230 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1154236 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1154242 | 100 | 0.000193178 | REHAU Compression sleeve, SDR 11 RX 125 x 11.4 | 4007360537012 | 12352291002 | 5696 | https://oxomi.com/p/3000126/datasheet/-/12352291002 | 1.597
1173557 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1173558 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1173563 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1173564 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1173593 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1173594 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1173921 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1173922 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1207313 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1207314 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1207315 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1210784 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1210785 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1210786 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1210915 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1210916 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1210917 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1211628 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1211636 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1212062 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213223 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213225 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213322 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213324 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213440 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213442 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213569 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213571 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213597 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213599 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1213607 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213609 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213617 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213619 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213627 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213629 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1213637 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213639 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213647 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213649 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213751 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213753 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1213790 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1284720 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1285145 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1285146 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1285158 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1285159 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1357858 | 90 | 0.000122841 | REHAU Compression sleeve, SDR 11 RX 110 x 10.0 | 4007360537005 | 12676911002 | 5695 | https://oxomi.com/p/3000126/datasheet/-/12676911002 | 1.09
1357864 | 100 | 0.000193178 | REHAU Compression sleeve, SDR 11 RX 125 x 11.4 | 4007360537012 | 12352291002 | 5696 | https://oxomi.com/p/3000126/datasheet/-/12352291002 | 1.597
1357870 | 110 | 0.000228348 | REHAU Compression sleeve, SDR 11 RX 140 x 12.7 | 4007360537692 | 12062561002 | 5697 | https://oxomi.com/p/3000126/datasheet/-/12062561002 | 1.8
1357876 | 125 | 0.000289995 | REHAU Compression sleeve, SDR 11 RX 160 x 14.6 | 4007360537029 | 12343241002 | 5698 | https://oxomi.com/p/3000126/datasheet/-/12343241002 | 2.45
1423081 | 65 | 0.0000520181 | REHAU Compression sleeve, SDR 11 RX 75 x 6.8 | 4007360536084 | 12676711002 | 5693 | https://oxomi.com/p/3000126/datasheet/-/12676711002 | 0.5
1423530 | 75 | 0.0000589797 | REHAU Compression sleeve, SDR 11 RX 90 x 8.2 | 4007360536091 | 12676811002 | 5694 | https://oxomi.com/p/3000126/datasheet/-/12676811002 | 0.52
1491242 | 110 | 0.000228348 | REHAU Compression sleeve, SDR 11 RX 140 x 12.7 | 4007360537692 | 12062561002 | 5697 | https://oxomi.com/p/3000126/datasheet/-/12062561002 | 1.8
1491243 | 110 | 0.000228348 | REHAU Compression sleeve, SDR 11 RX 140 x 12.7 | 4007360537692 | 12062561002 | 5697 | https://oxomi.com/p/3000126/datasheet/-/12062561002 | 1.8

# IfcPipeFitting: T-piece SDR11 LX:T-piece LX SDR11 LX (32)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: T-piece SDR11 LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: T-piece SDR11 LX; T2: T-piece SDR11 LX DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: T-piece LX SDR11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: T-piece SDR11 LX:T-piece LX SDR11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: T-piece SDR11 LX; Family and Type: T-piece SDR11 LX: T-piece LX SDR11 LX; Sleeve DN3: Sleeve : LX 11; Type: T-piece LX SDR11 LX; Type Id: 1200698
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (T-piece SDR11 LX:T-piece LX SDR11 LX:...) | DN1 (mm) | DN2 (mm) | DN3 (mm) | ID1 (mm) | ID2 (mm) | ID3 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Product URL | Weight
1201061 | 15 | 15 | 15 | 13.6 | 13.6 | 13.6 | 43.4 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000197867 | 25 | 28.4 | 25 | REHAU T-Stück SDR 11 LX 20 - 20 - 20 | 4007360456399 | 11690451001 | https://oxomi.com/p/3000126/datasheet/-/11690451001 | 0.135
1201304 | 20 | 20 | 20 | 17.8 | 17.8 | 17.8 | 52.6 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000320978 | 28.5 | 31.1 | 28.5 | REHAU T-Stück SDR 11 LX 25 - 25 - 25 | 4007360456504 | 11690561001 | https://oxomi.com/p/3000126/datasheet/-/11690561001 | 0.2
1201454 | 25 | 25 | 25 | 22.4 | 22.4 | 22.4 | 62 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000661913 | 34.5 | 35 | 34.5 | REHAU T-Stück SDR 11 LX 32 - 32 - 32 | 4007360456573 | 11690631001 | https://oxomi.com/p/3000126/datasheet/-/11690631001 | 0.4
1201548 | 32 | 32 | 32 | 26.4 | 26.4 | 26.4 | 77 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.000135307 | 34.3 | 45.3 | 34.3 | REHAU T-Stück SDR 11 LX 40 - 40 - 40 | 4007360456665 | 11690721001 | https://oxomi.com/p/3000126/datasheet/-/11690721001 | 0.77
1204903 | 40 | 40 | 40 | 35.5 | 35.5 | 35.5 | 88 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.000219559 | 45.8 | 49.2 | 45.8 | REHAU T-Stück, SDR 11 LX 50 - 50 - 50 | 4007360457990 | 11691561001 | https://oxomi.com/p/3000126/datasheet/-/11691561001 | 0.87
1207304 | 50 | 50 | 50 | 45.5 | 45.5 | 45.5 | 106 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.000385381 | 55.8 | 60 | 55.8 | REHAU T-Stück, SDR 11 LX 63 - 63 - 63 | 4007360458102 | 11691671001 | https://oxomi.com/p/3000126/datasheet/-/11691671001 | 2.35
1211083 | 20 | 15 | 15 | 17.8 | 13.6 | 13.6 | 46.1 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000234694 | 25 | 31.1 | 25 | REHAU T-Stück SDR 11 LX 25 - 20 - 20 | 4007360456436 | 11690491001 | https://oxomi.com/p/3000126/datasheet/-/11690491001 | 0.165
1211091 | 25 | 20 | 20 | 22.4 | 17.8 | 17.8 | 55.3 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000425594 | 29.8 | 34 | 28.8 | REHAU T-Stück SDR 11 LX 32 - 25 - 25 | 4007360456542 | 11690601001 | https://oxomi.com/p/3000126/datasheet/-/11690601001 | 0.259
1211099 | 32 | 25 | 25 | 27.5 | 22.4 | 22.4 | 69 | 32 | 25 | 32 mmø-25 mmø-25 mmø | 0.0000879087 | 35 | 42 | 35 | REHAU T-Stück SDR 11 LX 40 - 32 - 32 | 4007360456641 | 11690701001 | https://oxomi.com/p/3000126/datasheet/-/11690701001 | 0.58
1211107 | 40 | 20 | 32 | 35.8 | 17.8 | 27.2 | 68.5 | 40 | 20 | 40 mmø-32 mmø-20 mmø | 0.000132616 | 41.6 | 45.9 | 43 | REHAU T-Stück, SDR 11 LX 50 - 25 - 40 | 4007360457945 | 11691511001 | https://oxomi.com/p/3000126/datasheet/-/11691511001 | 0.82
1211115 | 40 | 25 | 32 | 36 | 22.8 | 27.8 | 75 | 40 | 25 | 40 mmø-32 mmø-25 mmø | 0.000131093 | 32.3 | 48.4 | 41.1 | REHAU T-Stück, SDR 11 LX 50 - 32 - 40 | 4007360457969 | 11691531001 | https://oxomi.com/p/3000126/datasheet/-/11691531001 | 0.72
1211123 | 50 | 25 | 40 | 44 | 22 | 35.2 | 82 | 50 | 25 | 50 mmø-40 mmø-25 mmø | 0.00023973 | 53 | 55 | 48.6 | REHAU T-Stück, SDR 11 LX 63 - 32 - 50 | 4007360458034 | 11691601001 | https://oxomi.com/p/3000126/datasheet/-/11691601001 | 1.2
1211346 | 50 | 32 | 32 | 45.5 | 27.5 | 27.5 | 88.5 | 50 | 32 | 50 mmø-32 mmø-32 mmø | 0.000207816 | 43.3 | 56.5 | 41.1 | REHAU T-Stück, SDR 11 LX 63 - 40 - 40 | 4007360458058 | 11691621001 | https://oxomi.com/p/3000126/datasheet/-/11691621001 | 1.5
1211536 | 50 | 32 | 40 | 45.5 | 27.5 | 35.5 | 88.5 | 50 | 32 | 50 mmø-40 mmø-32 mmø | 0.000231179 | 43.3 | 56.5 | 41.2 | REHAU T-Stück, SDR 11 LX 63 - 40 - 50 | 4007360458065 | 11691631001 | https://oxomi.com/p/3000126/datasheet/-/11691631001 | 1.6
1212364 | 20 | 15 | 20 | 17.8 | 13.6 | 17.8 | 46.1 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000270588 | 25.5 | 31.1 | 25.5 | REHAU T-Stück SDR 11 LX 25 - 20 - 25 | 4007360456474 | 11690531001 | https://oxomi.com/p/3000126/datasheet/-/11690531001 | 0.184
1212372 | 25 | 15 | 25 | 22.4 | 13.6 | 22.4 | 50.6 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000454284 | 26 | 35 | 26 | REHAU T-Stück SDR 11 LX 32 - 20 - 32 | 4007360456535 | 11690591001 | https://oxomi.com/p/3000126/datasheet/-/11690591001 | 0.29
1212380 | 25 | 20 | 25 | 22.4 | 17.8 | 22.4 | 56.5 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.0000521516 | 29.5 | 35 | 29.5 | REHAU T-Stück SDR 11 LX 32 - 25 - 32 | 4007360456559 | 11690611001 | https://oxomi.com/p/3000126/datasheet/-/11690611001 | 0.31
1212388 | 32 | 15 | 32 | 26.2 | 13.6 | 26.2 | 57.3 | 32 | 15 | 32 mmø-32 mmø-15 mmø | 0.0000912028 | 30.2 | 42.2 | 30.2 | REHAU T-Stück SDR 11 LX 40 - 20 - 40 | 4007360456627 | 11690681001 | https://oxomi.com/p/3000126/datasheet/-/11690681001 | 0.58
1212396 | 32 | 20 | 32 | 27.5 | 17.8 | 27.5 | 62 | 32 | 20 | 32 mmø-32 mmø-20 mmø | 0.0000879244 | 29.8 | 40.5 | 29.8 | REHAU T-Stück SDR 11 LX 40 - 25 - 40 | 4007360456634 | 11690691001 | https://oxomi.com/p/3000126/datasheet/-/11690691001 | 0.67
1212404 | 32 | 25 | 32 | 27 | 22.4 | 27 | 69 | 32 | 25 | 32 mmø-32 mmø-25 mmø | 0.000104817 | 31.8 | 42 | 31.8 | REHAU T-Stück SDR 11 LX 40 - 32 - 40 | 4007360456658 | 11690711001 | https://oxomi.com/p/3000126/datasheet/-/11690711001 | 0.7
1212412 | 40 | 15 | 40 | 35.5 | 13.6 | 35.5 | 60.8 | 40 | 15 | 40 mmø-40 mmø-15 mmø | 0.000119843 | 27.8 | 45.8 | 27.8 | REHAU T-Stück SDR 11 LX 50 - 20 - 50 | 4007360456726 | 11690771001 | https://oxomi.com/p/3000126/datasheet/-/11690771001 | 0.81
1212420 | 40 | 20 | 40 | 37 | 17.6 | 37 | 68.5 | 40 | 20 | 40 mmø-40 mmø-20 mmø | 0.000128117 | 33.4 | 47.3 | 33.4 | REHAU T-Stück, SDR 11 LX 50 - 25 - 50 | 4007360457952 | 11691521001 | https://oxomi.com/p/3000126/datasheet/-/11691521001 | 0.83
1212428 | 40 | 25 | 40 | 35.5 | 22.4 | 35.5 | 73.8 | 40 | 25 | 40 mmø-40 mmø-25 mmø | 0.000150988 | 35.2 | 46.8 | 35.2 | REHAU T-Stück, SDR 11 LX 50 - 32 - 50 | 4007360457976 | 11691541001 | https://oxomi.com/p/3000126/datasheet/-/11691541001 | 0.82
