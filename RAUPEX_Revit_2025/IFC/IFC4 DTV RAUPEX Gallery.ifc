Properties of the parts of a building model (IFC4), part 5 of 5

# IfcPipeFitting: T-piece SDR11 LX:T-piece LX SDR11 LX (32)
Name (T-piece SDR11 LX:T-piece LX SDR11 LX:...) | DN1 (mm) | DN2 (mm) | DN3 (mm) | ID1 (mm) | ID2 (mm) | ID3 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Product URL | Weight
1212790 | 40 | 32 | 40 | 35.5 | 27.5 | 35.5 | 80.5 | 40 | 32 | 40 mmø-40 mmø-32 mmø | 0.000182465 | 39.8 | 49 | 39.8 | REHAU T-Stück, SDR 11 LX 50 - 40 - 50 | 4007360457983 | 11691551001 | https://oxomi.com/p/3000126/datasheet/-/11691551001 | 0.9
1212798 | 50 | 20 | 50 | 45.5 | 17.8 | 45.5 | 74.7 | 50 | 20 | 50 mmø-50 mmø-20 mmø | 0.000207462 | 34.3 | 53.2 | 34.3 | REHAU T-Stück, SDR 11 LX 63 - 25 - 63 | 4007360458027 | 11691591001 | https://oxomi.com/p/3000126/datasheet/-/11691591001 | 1.2
1212914 | 50 | 25 | 50 | 45.5 | 22.4 | 45.5 | 84 | 50 | 25 | 50 mmø-50 mmø-25 mmø | 0.000227938 | 36.8 | 57 | 36.8 | REHAU T-Stück, SDR 11 LX 63 - 32 - 63 | 4007360458041 | 11691611001 | https://oxomi.com/p/3000126/datasheet/-/11691611001 | 1.2
1212992 | 50 | 32 | 50 | 45.5 | 27.5 | 45.5 | 88.5 | 50 | 32 | 50 mmø-50 mmø-32 mmø | 0.000271622 | 43.3 | 56.5 | 43.3 | REHAU T-Stück, SDR 11 LX 63 - 40 - 63 | 4007360458072 | 11691641001 | https://oxomi.com/p/3000126/datasheet/-/11691641001 | 1.7
1213088 | 50 | 40 | 50 | 45 | 35.5 | 45 | 95.5 | 50 | 40 | 50 mmø-50 mmø-40 mmø | 0.000323835 | 49.3 | 56.5 | 49.3 | REHAU T-Stück, SDR 11 LX 63 - 50 - 63 | 4007360458096 | 11691661001 | https://oxomi.com/p/3000126/datasheet/-/11691661001 | 1.9
1213780 | 15 | 20 | 15 | 13.6 | 17.8 | 13.6 | 49.9 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000239539 | 28.5 | 25.4 | 28.5 | REHAU T-Stück SDR 11 LX 20 - 25 - 20 | 4007360456412 | 11690471001 | https://oxomi.com/p/3000126/datasheet/-/11690471001 | 0.16
1213796 | 20 | 20 | 15 | 17.8 | 17.8 | 13.6 | 53 | 20 | 15 | 20 mmø-15 mmø-20 mmø | 0.0000284649 | 28 | 31.5 | 28 | REHAU T-Stück SDR 11 LX 25 - 25 - 20 | 4007360456498 | 11690551001 | https://oxomi.com/p/3000126/datasheet/-/11690551001 | 0.196
1213804 | 25 | 25 | 20 | 22.4 | 22.4 | 17.8 | 62.4 | 25 | 20 | 25 mmø-20 mmø-25 mmø | 0.0000559924 | 34.5 | 35.4 | 33.5 | REHAU T-Stück SDR 11 LX 32 - 32 - 25 | 4007360456566 | 11690621001 | https://oxomi.com/p/3000126/datasheet/-/11690621001 | 0.35
1688801 | 50 | 40 | 40 | 45.5 | 35.5 | 35.5 | 95.5 | 50 | 40 | 50 mmø-40 mmø-40 mmø | 0.000271528 | 49.3 | 56.5 | 45.8 | REHAU T-Stück, SDR 11 LX 63 - 50 - 50 | 4007360458089 | 11691651001 | https://oxomi.com/p/3000126/datasheet/-/11691651001 | 1.6

# IfcPipeFitting: T-piece SDR11 LX:T-piece SDR11 RX (18)
In: Level 1
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; Family Name: T-piece SDR11 LX; Max sleeve: 50 mm; T1: T-piece SDR11 LX; T2: T-piece SDR11 LX DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: RX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: T-piece SDR11 RX
Type - Materials and Finishes - Mat. Coupling: RAUTITAN RX+
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: T-piece SDR11 LX:T-piece SDR11 RX; sets with these values: 2
Other - IsCustom: no; Family: T-piece SDR11 LX; Family and Type: T-piece SDR11 LX: T-piece SDR11 RX; Type: T-piece SDR11 RX; Type Id: 1200700
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (T-piece SDR11 LX:T-piece SDR11 RX:...) | Sleeve DN1 | Sleeve DN2 | Sleeve DN3 | DN1 (mm) | DN2 (mm) | DN3 (mm) | ID1 (mm) | ID2 (mm) | ID3 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Product URL | Weight
1207312 | Sleeve : RX 11 | Sleeve : RX 11 | Sleeve : RX 11 | 75 | 75 | 75 | 69 | 69 | 69 | 132.5 | 75 | 75 | 75 mmø-75 mmø-75 mmø | 0.000897792 | 76.6 | 82.6 | 76.6 | REHAU T-Stück, SDR 11 RX 90 - 90 - 90 | 4007360258726 | 12219481001 | https://oxomi.com/p/3000126/datasheet/-/12219481001 | 4
1210783 | Sleeve : RX 11 | Sleeve : RX 11 | Sleeve : RX 11 | 90 | 90 | 90 | 83 | 83 | 83 | 136.5 | 90 | 90 | 90 mmø-90 mmø-90 mmø | 0.00146994 | 87.2 | 86.3 | 87.2 | REHAU T-Stück, SDR 11 RX 110 - 110 - 110 | 4007360267612 | 12219531001 | https://oxomi.com/p/3000126/datasheet/-/12219531001 | 6
1210914 | Sleeve : RX 11 | Sleeve : RX 11 | Sleeve : RX 11 | 65 | 65 | 65 | 54 | 54 | 54 | 123.5 | 65 | 65 | 65 mmø-65 mmø-65 mmø | 0.000635086 | 66.9 | 74.9 | 66.9 | REHAU T-Stück, SDR 11 RX 75 - 75 - 75 | 4007360258702 | 12219461001 | https://oxomi.com/p/3000126/datasheet/-/12219461001 | 2.7
1211627 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : LX 11 | 65 | 25 | 50 | 54 | 22.4 | 44 | 89 | 65 | 25 | 65 mmø-50 mmø-25 mmø | 0.000308339 | 41.9 | 62 | 41.5 | REHAU T-Stück, SDR 11 RX 75 - 32 - 63 | 4007360258658 | 12219351001 | https://oxomi.com/p/3000126/datasheet/-/12219351001 | 2.1
1211635 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : LX 11 | 65 | 40 | 50 | 53.9 | 33.5 | 44.8 | 101.7 | 65 | 40 | 65 mmø-50 mmø-40 mmø | 0.000460961 | 89.8 | 60.9 | 73.8 | REHAU T-Stück, SDR 11 RX 75 - 50 - 63 | 4007360258672 | 12219381001 | https://oxomi.com/p/3000126/datasheet/-/12219381001 | 2.4
1212061 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : LX 11 | 65 | 50 | 50 | 55.5 | 46.2 | 46.2 | 115.4 | 65 | 50 | 65 mmø-50 mmø-50 mmø | 0.000478382 | 60.4 | 68.2 | 59.9 | REHAU T-Stück, SDR 11 RX 75 - 63 - 63 | 4007360258689 | 12219431001 | https://oxomi.com/p/3000126/datasheet/-/12219431001 | 2.5
1213222 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 65 | 20 | 65 | 54 | 17.8 | 54 | 85.5 | 65 | 20 | 65 mmø-65 mmø-20 mmø | 0.000305864 | 37.1 | 61 | 37.1 | REHAU T-Stück, SDR 11 RX 75 - 25 - 75 | 4007360258641 | 12219341001 | https://oxomi.com/p/3000126/datasheet/-/12219341001 | 2.1
1213321 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 65 | 25 | 65 | 55 | 22.8 | 55 | 89 | 65 | 25 | 65 mmø-65 mmø-25 mmø | 0.00033719 | 42 | 62.8 | 42 | REHAU T-Stück, SDR 11 RX 75 - 32 - 75 | 4007360202149 | 12677911001 | https://oxomi.com/p/3000126/datasheet/-/12677911001 | 2.1
1213439 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 65 | 32 | 65 | 54 | 27 | 54 | 94.3 | 65 | 32 | 65 mmø-65 mmø-32 mmø | 0.000389734 | 46 | 62.4 | 46 | REHAU T-Stück, SDR 11 RX 75 - 40 - 75 | 4007360258665 | 12219361001 | https://oxomi.com/p/3000126/datasheet/-/12219361001 | 2.25
1213568 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 65 | 40 | 65 | 54.8 | 35.6 | 54.8 | 102 | 65 | 40 | 65 mmø-65 mmø-40 mmø | 0.000429952 | 51.7 | 64 | 51.7 | REHAU T-Stück, SDR 11 RX 75 - 50 - 75 | 4007360202071 | 12313261001 | https://oxomi.com/p/3000126/datasheet/-/12313261001 | 2.5
1213596 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 65 | 50 | 65 | 54 | 45 | 54 | 112.5 | 65 | 50 | 65 mmø-65 mmø-50 mmø | 0.000522992 | 58.9 | 66.5 | 58.9 | REHAU T-Stück, SDR 11 RX 75 - 63 - 75 | 4007360258696 | 12219441001 | https://oxomi.com/p/3000126/datasheet/-/12219441001 | 2.5
1213606 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 75 | 25 | 75 | 70 | 22 | 70 | 98 | 75 | 25 | 75 mmø-75 mmø-25 mmø | 0.000439738 | 41 | 72.5 | 41 | REHAU T-Stück, SDR 11 RX 90 - 32 - 90 | 4007360202088 | 12313361001 | https://oxomi.com/p/3000126/datasheet/-/12313361001 | 3
1213616 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 75 | 32 | 75 | 69 | 27 | 69 | 103.5 | 75 | 32 | 75 mmø-75 mmø-32 mmø | 0.000483317 | 45.9 | 71.5 | 45.9 | REHAU T-Stück, SDR 11 RX 90 - 40 - 90 | 4007360258719 | 12219451001 | https://oxomi.com/p/3000126/datasheet/-/12219451001 | 3.2
1213626 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 75 | 50 | 75 | 69.6 | 45.4 | 69.6 | 121 | 75 | 50 | 75 mmø-75 mmø-50 mmø | 0.000653555 | 58.8 | 75.1 | 58.8 | REHAU T-Stück, SDR 11 RX 90 - 63 - 90 | 4007360202095 | 12313461001 | https://oxomi.com/p/3000126/datasheet/-/12313461001 | 3.8
1213636 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 90 | 25 | 90 | 81.6 | 22.2 | 81.6 | 109 | 90 | 25 | 90 mmø-90 mmø-25 mmø | 0.000705113 | 41.1 | 81.5 | 41.1 | REHAU T-Stück, SDR 11 RX 110 - 32 -110 | 4007360202101 | 12313561001 | https://oxomi.com/p/3000126/datasheet/-/12313561001 | 4.3
1213646 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 90 | 40 | 90 | 84 | 35.2 | 84 | 122 | 90 | 40 | 90 mmø-90 mmø-40 mmø | 0.000800234 | 51.4 | 93.5 | 51.4 | REHAU T-Stück, SDR 11 RX 110 - 50 - 110 | 4007360258733 | 12219501001 | https://oxomi.com/p/3000126/datasheet/-/12219501001 | 4.7
1213750 | Sleeve : RX 11 | Sleeve : LX 11 | Sleeve : RX 11 | 90 | 50 | 90 | 82.2 | 44 | 82.2 | 132 | 90 | 50 | 90 mmø-90 mmø-50 mmø | 0.000966976 | 58.1 | 86.1 | 58.1 | REHAU T-Stück, SDR 11 RX 110 - 63 - 110 | 4007360202118 | 12313661001 | https://oxomi.com/p/3000126/datasheet/-/12313661001 | 5.4
1213788 | Sleeve : LX 11 | Sleeve : RX 11 | Sleeve : LX 11 | 50 | 65 | 50 | 45.3 | 53.6 | 45.3 | 108.6 | 65 | 50 | 65 mmø-50 mmø-50 mmø | 0.000480753 | 67 | 56.2 | 67 | REHAU T-Stück, SDR 11 RX 63 - 75 - 63 | 4007360202057 | 12677811001 | https://oxomi.com/p/3000126/datasheet/-/12677811001 | 1.69

# IfcPipeFitting: T-piece SDR11 internal thread LX:T-piece LX SDR11 internal LX (17)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: T-piece SDR11 internal thread LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: T-piece female thread SDR11 LX; T2: T-piece female thread SDR11 LX DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.04.10-419114-419114; Type Name: T-piece LX SDR11 internal LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: T-piece SDR11 internal thread LX:T-piece LX SDR11 internal LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: T-piece SDR11 internal thread LX; Family and Type: T-piece SDR11 internal thread LX: T-piece LX SDR11 internal LX; Sleeve DN3: Sleeve : LX 11; Type: T-piece LX SDR11 internal LX; Type Id: 1035391
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass Kleur: - brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (T-piece SDR11 internal thread LX:T-piece LX SDR11 internal LX:...) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | DN3 (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | ID3 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Product URL | Weight
1160547 | 15 | 15 | 15 | 17.6 | 13.6 | 18.6 | 13.6 | 24.5 | 15 mmø-15 mmø-15 mmø | 0.0000213573 | 28 | 14.5 | 28 | REHAU T-Stück SDR 11 LX 20 - Rp 1/2 - 20 | 4007360456429 | 11690481001 | https://oxomi.com/p/3000126/datasheet/-/11690481001 | 0.151
1160565 | 20 | 15 | 20 | 22 | 17.8 | 18.7 | 17.8 | 25.5 | 20 mmø-20 mmø-15 mmø | 0.0000285616 | 28 | 14.8 | 28 | REHAU T-Stück SDR 11 LX 25 - Rp 1/2 - 25 | 4007360456511 | 11690571001 | https://oxomi.com/p/3000126/datasheet/-/11690571001 | 0.215
1160573 | 20 | 20 | 20 | 22 | 17.8 | 24.2 | 17.8 | 27.5 | 20 mmø-20 mmø-20 mmø | 0.0000346167 | 31.3 | 15.5 | 31.3 | REHAU T-Stück SDR 11 LX 25 - Rp 3/4 - 25 | 4007360456528 | 11690581001 | https://oxomi.com/p/3000126/datasheet/-/11690581001 | 0.225
1160581 | 25 | 15 | 25 | 28.7 | 22.4 | 18.8 | 22.4 | 28 | 25 mmø-25 mmø-15 mmø | 0.0000500325 | 29 | 17 | 29 | REHAU T-Stück SDR 11 LX 32 - Rp 1/2 - 32 | 4007360456580 | 11690641001 | https://oxomi.com/p/3000126/datasheet/-/11690641001 | 0.275
1160589 | 25 | 20 | 25 | 27.9 | 22.4 | 24.1 | 22.4 | 30 | 25 mmø-25 mmø-20 mmø | 0.0000557489 | 32.3 | 13.3 | 32.3 | REHAU T-Stück SDR 11 LX 32 - Rp 3/4 - 32 | 4007360456610 | 11690671001 | https://oxomi.com/p/3000126/datasheet/-/11690671001 | 0.345
1160597 | 32 | 15 | 32 | 36 | 27.5 | 18.7 | 27.5 | 39.5 | 32 mmø-32 mmø-15 mmø | 0.0000881784 | 31 | 24 | 31 | REHAU T-Stück SDR 11 LX 40 - Rp 1/2 - 40 | 4007360456672 | 11690731001 | https://oxomi.com/p/3000126/datasheet/-/11690731001 | 0.56
1160605 | 32 | 20 | 32 | 35.3 | 26.6 | 24.8 | 26.6 | 40.3 | 32 mmø-32 mmø-20 mmø | 0.000104837 | 35.4 | 18.1 | 35.4 | REHAU T-Stück SDR 11 LX 40 - Rp 3/4 - 40 | 4007360456719 | 11690761001 | https://oxomi.com/p/3000126/datasheet/-/11690761001 | 0.613
1160613 | 32 | 25 | 32 | 36.3 | 27.2 | 31 | 27.2 | 37.4 | 32 mmø-32 mmø-25 mmø | 0.000122056 | 39 | 20.3 | 39 | REHAU T-Stück SDR 11 LX 40 - Rp 1 - 40 | 4007360456702 | 11690751001 | https://oxomi.com/p/3000126/datasheet/-/11690751001 | 0.7
1160621 | 32 | 32 | 32 | 36 | 27.5 | 38.9 | 27.5 | 41 | 32 mmø-32 mmø-32 mmø | 0.000120244 | 42.3 | 25.5 | 42.3 | REHAU T-Stück SDR 11 LX 40 - Rp 1 1/4 - 40 | 4061264935749 | 11691771001 | https://oxomi.com/p/3000126/datasheet/-/11691771001 | 0.699
1160629 | 40 | 15 | 40 | 44.3 | 35.5 | 18.7 | 35.5 | 40 | 40 mmø-40 mmø-15 mmø | 0.000127938 | 31 | 24.7 | 31 | REHAU T-Stück SDR 11 LX 50 - Rp 1/2 - 50 | 4007360456740 | 11690791001 | https://oxomi.com/p/3000126/datasheet/-/11690791001 | 0.807
1160637 | 40 | 20 | 40 | 44.3 | 35.5 | 24.2 | 35.5 | 46.9 | 40 mmø-40 mmø-20 mmø | 0.000143268 | 34.3 | 34 | 34.3 | REHAU T-Stück SDR 11 LX 50 - Rp 3/4 - 50 | 4007360456757 | 11690801001 | https://oxomi.com/p/3000126/datasheet/-/11690801001 | 1.02
1160645 | 40 | 25 | 40 | 43.3 | 35.5 | 31.7 | 35.5 | 42 | 40 mmø-40 mmø-25 mmø | 0.000145292 | 37.8 | 27.8 | 37.8 | REHAU T-Stück SDR 11 LX 50 - Rp 1 - 50 | 4007360458010 | 11691581001 | https://oxomi.com/p/3000126/datasheet/-/11691581001 | 0.93
1160653 | 40 | 32 | 40 | 44.3 | 36 | 39 | 36 | 45 | 40 mmø-40 mmø-32 mmø | 0.000191885 | 45.5 | 33.4 | 45.5 | REHAU T-Stück SDR 11 LX 50 - Rp 1 1/4 - 50 | 4007360456733 | 11690781001 | https://oxomi.com/p/3000126/datasheet/-/11690781001 | 0.97
1160661 | 50 | 15 | 50 | 55.1 | 45.5 | 18.9 | 45.5 | 54.5 | 50 mmø-50 mmø-15 mmø | 0.000204867 | 34.5 | 43.4 | 34.5 | REHAU T-Stück SDR 11 LX 63 - Rp 1/2 - 63 | 4007360456771 | 11690821001 | https://oxomi.com/p/3000126/datasheet/-/11690821001 | 1.1
1160669 | 50 | 20 | 50 | 55.1 | 45.5 | 24 | 45.5 | 49 | 50 mmø-50 mmø-20 mmø | 0.000220912 | 36.8 | 38 | 36.8 | REHAU T-Stück SDR 11 LX 63 - Rp 3/4 - 63 | 4007360456788 | 11690831001 | https://oxomi.com/p/3000126/datasheet/-/11690831001 | 1.27
1197117 | 32 | 25 | 25 | 36 | 27.5 | 30.7 | 22.4 | 36.5 | 32 mmø-25 mmø-25 mmø | 0.0000814731 | 37.8 | 17.8 | 35.8 | REHAU T-Stück SDR 11 LX 40 - Rp 1 - 32 | 4007360457556 | 11690741001 | https://oxomi.com/p/3000126/datasheet/-/11690741001 | 0.61
1197130 | 40 | 32 | 32 | 44.8 | 35.4 | 39.4 | 27.2 | 42.5 | 40 mmø-32 mmø-32 mmø | 0.000155019 | 45.8 | 32.3 | 45 | REHAU T-Stück, SDR 11 LX 50 - Rp 1 1/4 - 40 | 4007360458003 | 11691571001 | https://oxomi.com/p/3000126/datasheet/-/11691571001 | 0.89

# IfcPipeFitting: T-piece SDR11 outlet 90 degree LX:T-piece outlet 90 degree SDR11 LX, T-piece SDR11 outlet 90 degree LX:T-piece outlet 90 degree SDR11 LX:1560502
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: T-piece SDR11 outlet 90 degree LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: T-piece SDR11 outlet 90 degree LX; T2: T-piece SDR11 outlet 90 degree LX DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: T-piece outlet 90 degree SDR11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat); Group: Domestic Cold Water 74
Pset_EnvironmentalImpactIndicators - Reference: T-piece SDR11 outlet 90 degree LX:T-piece outlet 90 degree SDR11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: T-piece SDR11 outlet 90 degree LX; Family and Type: T-piece SDR11 outlet 90 degree LX: T-piece outlet 90 degree SDR11 LX; Sleeve DN3: Sleeve : LX 11; Type: T-piece outlet 90 degree SDR11 LX; Type Id: 1560379; X2: 60 mm
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00844196 m2; DN1: 25 mm; DN2: 25 mm; DN3: 25 mm; Dr1: 40 mm; HD1: 50 mm; ID1: 22.4 mm; Maximum Size: 25 mm; Minimum Size: 25 mm; Size: 25 mmø-25 mmø-25 mmø; Volume: 0.0000779037 m3; X: 90 mm; Z1: 35.8 mm; Z2: 15 mm; Z3: 35.8 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; Description long: REHAU T-Stück Abgang 90 Grad, SDR 11 LX 32 - 32 - 32; ETIM Class code: EC003025; GTIN: 4007360488796; PID: 12098891001; Product URL: https://oxomi.com/p/3000126/datasheet/-/12098891001; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - outlet above transit zone - realisation of steps above parallel mounted pipes Materiaal: - Brass Kleur: - brass; Weight: 0.58
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water; System Name: Domestic Cold Water 74
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 25 mmø-25 mmø-25 mmø

# IfcPipeFitting: T-piece SDR11 outlet 90 degree short LX:T-piece outlet 90 degree SDR11 short LX, T-piece SDR11 outlet 90 degree short LX:T-piece outlet 90 degree SDR11 short LX:1597063
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: T-piece SDR11 outlet 90 degree short LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : LX 11; T1: T-piece SDR11 outlet 90 degree LX short; T2: T-piece SDR11 outlet 90 degree LX short DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: T-piece outlet 90 degree SDR11 short LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: T-piece SDR11 outlet 90 degree short LX:T-piece outlet 90 degree SDR11 short LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: T-piece SDR11 outlet 90 degree short LX; Family and Type: T-piece SDR11 outlet 90 degree short LX: T-piece outlet 90 degree SDR11 short LX; Sleeve DN3: Sleeve : LX 11; Type: T-piece outlet 90 degree SDR11 short LX; Type Id: 1053092
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00844196 m2; DN1: 32 mm; DN2: 32 mm; DN3: 32 mm; Dr1: 24.5 mm; Dr2: 24.5 mm; HD1: 100 mm; ID1: 27.5 mm; Maximum Size: 32 mm; Minimum Size: 32 mm; Size: 32 mmø-32 mmø-32 mmø; Volume: 0.000160243 m3; X: 51 mm; Z1: 42.3 mm; Z2: 25.5 mm; Z3: 42.3 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; Description long: REHAU T-Stück Abgang 90 Grad, SDR 11 LX 40 - 40 - 40 kurz; ETIM Class code: EC003025; GTIN: 4062178701680; PID: 12099241001; Product URL: https://oxomi.com/p/3000126/datasheet/-/12099241001; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - outlet above transit zone - realisation of steps above parallel mounted pipes Materiaal: - Brass Kleur: - brass; Weight: 1.118
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 32 mmø-32 mmø-32 mmø

# IfcPipeFitting: T-piece taper SDR11 LX:T-piece taper SDR11, T-piece taper SDR11 LX:T-piece taper SDR11:1327808
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: T-piece taper SDR11 LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: T-piece taper SDR11 LX; T2: T-piece taper SDR11 LX DN1-DN3; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: T-piece taper SDR11
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: T-piece taper SDR11 LX:T-piece taper SDR11; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: T-piece taper SDR11 LX; Family and Type: T-piece taper SDR11 LX: T-piece taper SDR11; Sleeve DN3: Sleeve : LX 11; Type: T-piece taper SDR11; Type Id: 1327677
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2; DN1: 25 mm; DN2: 15 mm; DN3: 25 mm; ID1: 22.4 mm; ID2: 13 mm; ID3: 22.4 mm; L2: 31.5 mm; Maximum Size: 25 mm; Minimum Size: 15 mm; Size: 25 mmø-25 mmø-15 mmø; Volume: 0.0000411078 m3; Z1: 26 mm; Z2: 20.6 mm; Z3: 26 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; Description long: REHAU T-Stück Abg. Konus, SDR 11 32 - G 1/2 - 32, 60 Grad; ETIM Class code: EC003025; GTIN: 4007360484385; PID: 11691691001; Product URL: https://oxomi.com/p/3000126/datasheet/-/11691691001; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - outlet with external thread with 60° conus Materiaal: - Brass Kleur: - brass; Weight: 0.38
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 25 mmø-25 mmø-15 mmø

# IfcPipeSegment: Pipe Types:RAUPEX-A Rohr, SDR11, grau bar (11)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUPEX-A Rohr, SDR11, grau bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPEX-A Rohr, SDR11, grau bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPEX-A Rohr, SDR11, grau bar; Type: RAUPEX-A Rohr, SDR11, grau bar; Type Id: 855969
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Connection Type: Generic; Material: RAUPEX-A Rohr, SDR11, grau bar; Pipe Segment: RAUPEX-A Rohr, SDR11, grau bar - 15 - 125; Roughness: 0.007 mm; Schedule/Type: 15 - 125; System Classification: Domestic Cold Water; System Type: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction: 0 kg/m2/s2; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPEX-A Rohr, SDR11, grau bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1085543 | -8.1 | -10 | 8.1 | 10 | 16.2 | 20 | 15 mmø | 1.9 | 0.0471239 | 15 | Domestic Cold Water 1 | 0.000432099
1085623 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 2 | 0.000343137
1085641 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 3 | 0.000267176
1085646 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 4 | 0.000214724
1085651 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 5 | 0.000171569
1085656 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 6 | 0.000136187
1085661 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 7 | 0.000114007
1085666 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 8 | 0.0000951087
1085671 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 9 | 0.0000777778
1085676 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 10 | 0.0000684932
1085681 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 11 | 0.0000535168

# IfcPipeSegment: Pipe Types:RAUPEX-K Rohr, SDR11, grün bar (11)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUPEX-K Rohr, SDR11, grün bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPEX-K Rohr, SDR11, grün bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPEX-K Rohr, SDR11, grün bar; Type: RAUPEX-K Rohr, SDR11, grün bar; Type Id: 1371498
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Schedule/Type: 15 - 125; System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUPEX-K Rohr, SDR11, grün bar; Pipe Segment: RAUPEX-K Rohr, SDR11, grün bar - 15 - 125; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPEX-K Rohr, SDR11, grün bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1086086 | -8.1 | -10 | 8.1 | 10 | 16.2 | 20 | 15 mmø | 1.9 | 0.0471239 | 15 | Domestic Cold Water 12 | 0.000432099
1086088 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 13 | 0.000343137
1086090 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 14 | 0.000267176
1086092 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 15 | 0.000214724
1086094 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 16 | 0.000171569
1086096 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 17 | 0.000136187
1086098 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 18 | 0.000114007
1086100 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 19 | 0.0000951087
1086102 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 20 | 0.0000777778
1086104 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 21 | 0.0000684932
1086106 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 22 | 0.0000535168

# IfcPipeSegment: Pipe Types:RAUPEX-M Rohr, SDR11, rot bar (11)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUPEX-M Rohr, SDR11, rot bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPEX-M Rohr, SDR11, rot bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPEX-M Rohr, SDR11, rot bar; Type: RAUPEX-M Rohr, SDR11, rot bar; Type Id: 1371556
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Schedule/Type: 15 - 125; System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUPEX-M Rohr, SDR11, rot bar; Pipe Segment: RAUPEX-M Rohr, SDR11, rot bar - 15 - 125; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPEX-M Rohr, SDR11, rot bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1086136 | -8.1 | -10 | 8.1 | 10 | 16.2 | 20 | 15 mmø | 1.9 | 0.0471239 | 15 | Domestic Cold Water 23 | 0.000432099
1086138 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 24 | 0.000343137
1086140 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 25 | 0.000267176
1086142 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 26 | 0.000214724
1086144 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 27 | 0.000171569
1086146 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 28 | 0.000136187
1086148 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 29 | 0.000114007
1086150 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 30 | 0.0000951087
1086152 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 31 | 0.0000777778
1086154 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 32 | 0.0000684932
1086156 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 33 | 0.0000535168

# IfcPipeSegment: Pipe Types:RAUPEX-O Rohr, SDR11, blau bar (11)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUPEX-O Rohr, SDR11, blau bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPEX-O Rohr, SDR11, blau bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPEX-O Rohr, SDR11, blau bar; Type: RAUPEX-O Rohr, SDR11, blau bar; Type Id: 1371594
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUPEX-O Rohr, SDR11, blau bar; Pipe Segment: RAUPEX-O Rohr, SDR11, blau bar - 15 -125; Roughness: 0.007 mm; Schedule/Type: 15 -125; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPEX-O Rohr, SDR11, blau bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1086171 | -8.1 | -10 | 8.1 | 10 | 16.2 | 20 | 15 mmø | 1.9 | 0.0471239 | 15 | Domestic Cold Water 34 | 0.000432099
1086173 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 35 | 0.000343137
1086175 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 36 | 0.000267176
1086177 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 37 | 0.000214724
1086179 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 38 | 0.000171569
1086181 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 39 | 0.000136187
1086183 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 40 | 0.000114007
1086185 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 41 | 0.0000951087
1086187 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 42 | 0.0000777778
1086189 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 43 | 0.0000684932
1086191 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 44 | 0.0000535168

# IfcPipeSegment: Pipe Types:RAUPEX-UV Rohr, SDR11, schwarz bar (11)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUPEX-UV Rohr, SDR11, schwarz bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPEX-UV Rohr, SDR11, schwarz bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPEX-UV Rohr, SDR11, schwarz bar; Type: RAUPEX-UV Rohr, SDR11, schwarz bar; Type Id: 1371632
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Schedule/Type: 15 - 125; System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUPEX-UV Rohr, SDR11, schwarz bar; Pipe Segment: RAUPEX-UV Rohr, SDR11, schwarz bar - 15 - 125; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPEX-UV Rohr, SDR11, schwarz bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1086206 | -8.1 | -10 | 8.1 | 10 | 16.2 | 20 | 15 mmø | 1.9 | 0.0471239 | 15 | Domestic Cold Water 45 | 0.000432099
1086208 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 46 | 0.000343137
1086210 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 47 | 0.000267176
1086212 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 48 | 0.000214724
1086214 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 49 | 0.000171569
1086216 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 50 | 0.000136187
1086218 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 51 | 0.000114007
1086220 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 52 | 0.0000951087
1086222 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 53 | 0.0000777778
1086224 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 54 | 0.0000684932
1086226 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 55 | 0.0000535168

# IfcPipeSegment: Pipe Types:RAUTHERM FW Rohr, SDR11, rot bar (10)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: Industrierohrsysteme; Type Comments: DN 15-125; Type Name: RAUTHERM FW Rohr, SDR11, rot bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTHERM FW Rohr, SDR11, rot bar; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTHERM FW Rohr, SDR11, rot bar; Type: RAUTHERM FW Rohr, SDR11, rot bar; Type Id: 1371676
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Level 1; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUTHERM FW Rohr, SDR11, rot bar; Pipe Segment: RAUTHERM FW Rohr, SDR11, rot bar - 20 - 125; Roughness: 0.007 mm; Schedule/Type: 20 - 125; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTHERM FW Rohr, SDR11, rot bar:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1086289 | -10.2 | -12.5 | 10.2 | 12.5 | 20.4 | 25 | 20 mmø | 2.3 | 0.0628319 | 20 | Domestic Cold Water 57 | 0.000343137
1086291 | -13.1 | -16 | 13.1 | 16 | 26.2 | 32 | 25 mmø | 2.9 | 0.0785398 | 25 | Domestic Cold Water 58 | 0.000267176
1086293 | -16.3 | -20 | 16.3 | 20 | 32.6 | 40 | 32 mmø | 3.7 | 0.100531 | 32 | Domestic Cold Water 59 | 0.000214724
1086295 | -20.4 | -25 | 20.4 | 25 | 40.8 | 50 | 40 mmø | 4.6 | 0.125664 | 40 | Domestic Cold Water 60 | 0.000171569
1086297 | -25.7 | -31.5 | 25.7 | 31.5 | 51.4 | 63 | 50 mmø | 5.8 | 0.15708 | 50 | Domestic Cold Water 61 | 0.000136187
1086299 | -30.7 | -37.5 | 30.7 | 37.5 | 61.4 | 75 | 65 mmø | 6.8 | 0.204204 | 65 | Domestic Cold Water 62 | 0.000114007
1086301 | -36.8 | -45 | 36.8 | 45 | 73.6 | 90 | 75 mmø | 8.2 | 0.235619 | 75 | Domestic Cold Water 63 | 0.0000951087
1086303 | -45 | -55 | 45 | 55 | 90 | 110 | 90 mmø | 10 | 0.282743 | 90 | Domestic Cold Water 64 | 0.0000777778
1086305 | -51.1 | -62.5 | 51.1 | 62.5 | 102.2 | 125 | 100 mmø | 11.4 | 0.314159 | 100 | Domestic Cold Water 65 | 0.0000684932
1086307 | -65.4 | -80 | 65.4 | 80 | 130.8 | 160 | 125 mmø | 14.6 | 0.392699 | 125 | Domestic Cold Water 66 | 0.0000535168
