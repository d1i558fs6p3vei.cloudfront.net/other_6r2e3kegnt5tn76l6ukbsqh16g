Properties of the parts of a building model (IFC4), part 3 of 5

# IfcPipeFitting: FUSAPEX 2.0 coupler:C 2.0 (72)
Name (FUSAPEX 2.0 coupler:C 2.0:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | HD3/2 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
2002495 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2002595 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2002881 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2002940 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2003420 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071004 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2071044 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2071095 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2071097 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2071110 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2071112 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071114 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2071126 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071128 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2071144 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090247 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090249 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090251 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090253 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090255 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090257 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090261 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090267 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090273 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090279 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090285 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090291 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090297 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090303 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090309 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090311 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090315 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090317 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090319 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090321 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090323 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090325 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090327 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090329 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090387 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2090432 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090480 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090560 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090618 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090682 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090734 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090812 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090864 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090988 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2091040 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2091107 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2091151 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2091193 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2091249 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998

# IfcPipeFitting: FUSAPEX 2.0 male Adapter:C 2.0 (3)
In: Level 1
Type - Material: FUSAPEX 2.0, Br
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX 2.0 male Adapter; T1: FUSAPEX 2.0 male Adapter; T2: FUSAPEX 2.0 male Adapter DN1-2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: C 2.0
Type - Materials and Finishes - Mat. Coupling: FUSAPEX 2.0; Mat. Coupling 2: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX 2.0 male Adapter:C 2.0; sets with these values: 2
Other - IsCustom: no; Type 0: no; Type 1: yes; Type: C 2.0; Family: FUSAPEX 2.0 male Adapter; Family and Type: FUSAPEX 2.0 male Adapter: C 2.0; Type Id: 1698212
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - A: 60 deg; Area: 0.00281399 m2; HD1: 17 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for FUSAPEX reducers and flange transitions Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - external thread according DIN 2999 made of brass CW 602 N - Tested according to DIN EN ISO 15875-5 Kleur: - Orange Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX 2.0 male Adapter:C 2.0:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | DoF2 (mm) | Dr2 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | HD3/2 (mm) | ID1 (mm) | ID2 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | SW (mm) | SW 2 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1698229 | 40 | 56.3 | 45.9 | 58 | 51 | 22.85 | 15.2 | 6.7 | 50 | 38.2 | 50 | 87 | 40 mmø-40 mmø | 55 | 27.5 | 9 | 0.000170019 | 1 | 60.1 | FUSAPEX 2.0 Übergang mit AG 50 - R 1 1/2, orange | 4062178993283 | 14847311001 | https://oxomi.com/p/3000126/datasheet/-/14847311001 | 0.548
1706680 | 50 | 69 | 60 | 71 | 57 | 22.5 | 17.6 | 9.1 | 63 | 57 | 59 | 99 | 50 mmø-50 mmø | 70 | 35 | 11.5 | 0.000244247 | 2 | 68 | FUSAPEX 2.0 Übergang mit AG 63 - R 2, orange | 4062178993290 | 14847321001 | https://oxomi.com/p/3000126/datasheet/-/14847321001 | 0.9
1706723 | 65 | 82.3 | 75.2 | 84.8 | 64 | 22.85 | 19 | 10.5 | 75 | 60 | 63 | 109 | 65 mmø-65 mmø | 85 | 42.5 | 11.5 | 0.000428882 | 2 | 74.5 | FUSAPEX 2.0 Übergang mit AG 75 - R 2 1/2, orange | 4062178993306 | 14847331001 | https://oxomi.com/p/3000126/datasheet/-/14847331001 | 1.477

# IfcPipeFitting: FUSAPEX Geo Elbow:Geo Elbow (2)
In: Level 1
Type - Material: RAUGEO
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX Geo Elbow; T1: FUSAPEX Geo elbow; T2: FUSAPEX Geo elbow DN1-2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; REHAU Info: 2025.07.21-419114-419114; Type Name: Geo Elbow
Type - Materials and Finishes - Mat. Coupling: RAUGEO
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX Geo Elbow:Geo Elbow; sets with these values: 2
Other - IsCustom: no; Angle check: 90 deg; Family: FUSAPEX Geo Elbow; Family and Type: FUSAPEX Geo Elbow: Geo Elbow; Type: Geo Elbow; Type Id: 1696730
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 90 deg; Area: 0.00281399 m2; HD1: 17 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUGEO Sonde PE-Xa green, RAUGEO collect, RAUGEO collect plus - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUTHERM FW SDR 11 Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 Kleur: - Green Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX Geo Elbow:Geo Elbow:...) | DN1 (mm) = DN2 (mm) = ID1 (mm) = ID2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Do2 (mm) | DoF1 (mm) | HD2 (mm) | HD3 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1696747 | 25 | 22 | 44 | 32 | 43 | 13.4 | 63.2 | 25 mmø-25 mmø | 0.000139822 | 40 | FUSAPEX Geo Winkel 32, 90 Grad | 4059757763832 | 13254631001 | https://oxomi.com/p/3000126/datasheet/-/13254631001 | 0.09
1711250 | 32 | 27.5 | 55 | 40 | 47 | 12 | 67.3 | 32 mmø-32 mmø | 0.000225908 | 44 | FUSAPEX Geo Winkel 40, 90 Grad | 4059757763863 | 13254641001 | https://oxomi.com/p/3000126/datasheet/-/13254641001 | 0.145

# IfcPipeFitting: FUSAPEX Geo coupler:Geo coupler (2)
In: Level 1
Type - Material: RAUGEO
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX Geo coupler; T1: FUSAPEX Geo coupler; T2: FUSAPEX Geo coupler DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.07.21-419114-419114; Type Name: Geo coupler
Type - Materials and Finishes - Mat. Coupling: RAUGEO
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX Geo coupler:Geo coupler; sets with these values: 2
Other - IsCustom: no; Family: FUSAPEX Geo coupler; Family and Type: FUSAPEX Geo coupler: Geo coupler; Type: Geo coupler; Type Id: 1695228
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2; HD1: 17 mm; Z1: 1 mm; Z2: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUGEO Sonde PE-Xa green, RAUGEO collect, RAUGEO collect plus - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUTHERM FW SDR 11 Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 Kleur: - Green Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX Geo coupler:Geo coupler:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | HD3/2 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product URL | Weight
1695245 | 25 | 35.8 | 42 | 24.1 | 12.2 | 3.7 | 32 | 40 | 25 mmø-25 mmø | 0.0000586822 | FUSAPEX Geo Muffe 32, grün | 4059757763856 | 13254611001 | https://oxomi.com/p/3000126/datasheet/-/13254611001 | 0.065
1711162 | 32 | 50.4 | 46 | 20.8 | 13.5 | 5 | 40 | 45 | 32 mmø-32 mmø | 0.000110008 | FUSAPEX Geo Muffe 40, grün | 4059757763849 | 13254621001 | https://oxomi.com/p/3000126/datasheet/-/13254621001 | 0.1

# IfcPipeFitting: FUSAPEX reducer for T-Piece:R (29)
In: Level 1
Type - Material: PE-Xa white
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX reducer for T-Piece; T1: FUSAPEX reducer; T2: FUSAPEX reducer DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: R
Type - Materials and Finishes - Mat. Coupling: PE-Xa white
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX reducer for T-Piece:R; sets with these values: 2
Other - IsCustom: no; Family: FUSAPEX reducer for T-Piece; Family and Type: FUSAPEX reducer for T-Piece: R; Type: R; Type Id: 2095353
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - patented current efficient construction in compact design - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - pressure: 6 bar Materiaal: - PE-X Kleur: - Natural
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX reducer for T-Piece:R:...) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | DN2 (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product URL | Weight
1982315 | 65 | 50 | 72.8 | 60.5 | 50.5 | 61 | 57 | 65 mmø | 0.000141264 | FUSAPEX Reduzierstück 75 - 63 | 4007360488482 | 12144011001 | https://oxomi.com/p/3000126/datasheet/-/12144011001 | 0.29
1988439 | 75 | 65 | 87.7 | 72.5 | 60.5 | 71 | 61 | 75 mmø | 0.000222481 | FUSAPEX Reduzierstück 90 - 75 | 4007360402983 | 12036041001 | https://oxomi.com/p/3000126/datasheet/-/12036041001 | 0.29
1988499 | 90 | 65 | 107.7 | 88.8 | 60.5 | 79 | 61 | 90 mmø | 0.000329073 | FUSAPEX Reduzierstück 110 - 75 | 4007360402990 | 12036051001 | https://oxomi.com/p/3000126/datasheet/-/12036051001 | 0.464
2002418 | 90 | 75 | 107.7 | 88.8 | 72.5 | 79 | 71 | 90 mmø | 0.000378606 | FUSAPEX Reduzierstück 110 - 90 | 4007360403003 | 12036071001 | https://oxomi.com/p/3000126/datasheet/-/12036071001 | 0.485
2002491 | 100 | 75 | 122.6 | 101.7 | 73 | 83 | 71 | 100 mmø | 0.00049148 | FUSAPEX Reduzierstück 125 - 90 | 4007360403027 | 12036111001 | https://oxomi.com/p/3000126/datasheet/-/12036111001 | 0.658
2002877 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2003416 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2090259 | 65 | 50 | 72.8 | 60.5 | 50.5 | 61 | 57 | 65 mmø | 0.000141264 | FUSAPEX Reduzierstück 75 - 63 | 4007360488482 | 12144011001 | https://oxomi.com/p/3000126/datasheet/-/12144011001 | 0.29
2090265 | 75 | 65 | 87.7 | 72.5 | 60.5 | 71 | 61 | 75 mmø | 0.000222481 | FUSAPEX Reduzierstück 90 - 75 | 4007360402983 | 12036041001 | https://oxomi.com/p/3000126/datasheet/-/12036041001 | 0.29
2090271 | 90 | 65 | 107.7 | 88.8 | 60.5 | 79 | 61 | 90 mmø | 0.000329073 | FUSAPEX Reduzierstück 110 - 75 | 4007360402990 | 12036051001 | https://oxomi.com/p/3000126/datasheet/-/12036051001 | 0.464
2090277 | 90 | 75 | 107.7 | 88.8 | 72.5 | 79 | 71 | 90 mmø | 0.000378606 | FUSAPEX Reduzierstück 110 - 90 | 4007360403003 | 12036071001 | https://oxomi.com/p/3000126/datasheet/-/12036071001 | 0.485
2090283 | 100 | 75 | 122.6 | 101.7 | 73 | 83 | 71 | 100 mmø | 0.00049148 | FUSAPEX Reduzierstück 125 - 90 | 4007360403027 | 12036111001 | https://oxomi.com/p/3000126/datasheet/-/12036111001 | 0.658
2090295 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2090307 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2090385 | 50 | 40 | 61.1 | 50.5 | 40 | 57 | 49 | 50 mmø | 0.000090293 | FUSAPEX Reduzierstück 63 - 50 | 4007360488468 | 12143981001 | https://oxomi.com/p/3000126/datasheet/-/12143981001 | 0.29
2090430 | 65 | 50 | 72.8 | 60.5 | 50.5 | 61 | 57 | 65 mmø | 0.000141264 | FUSAPEX Reduzierstück 75 - 63 | 4007360488482 | 12144011001 | https://oxomi.com/p/3000126/datasheet/-/12144011001 | 0.29
2090472 | 65 | 50 | 72.8 | 60.5 | 50.5 | 61 | 57 | 65 mmø | 0.000141264 | FUSAPEX Reduzierstück 75 - 63 | 4007360488482 | 12144011001 | https://oxomi.com/p/3000126/datasheet/-/12144011001 | 0.29
2090558 | 75 | 65 | 87.7 | 72.5 | 60.5 | 71 | 61 | 75 mmø | 0.000222481 | FUSAPEX Reduzierstück 90 - 75 | 4007360402983 | 12036041001 | https://oxomi.com/p/3000126/datasheet/-/12036041001 | 0.29
2090616 | 90 | 65 | 107.7 | 88.8 | 60.5 | 79 | 61 | 90 mmø | 0.000329073 | FUSAPEX Reduzierstück 110 - 75 | 4007360402990 | 12036051001 | https://oxomi.com/p/3000126/datasheet/-/12036051001 | 0.464
2090680 | 75 | 65 | 87.7 | 72.5 | 60.5 | 71 | 61 | 75 mmø | 0.000222481 | FUSAPEX Reduzierstück 90 - 75 | 4007360402983 | 12036041001 | https://oxomi.com/p/3000126/datasheet/-/12036041001 | 0.29
2090726 | 90 | 75 | 107.7 | 88.8 | 72.5 | 79 | 71 | 90 mmø | 0.000378606 | FUSAPEX Reduzierstück 110 - 90 | 4007360403003 | 12036071001 | https://oxomi.com/p/3000126/datasheet/-/12036071001 | 0.485
2090810 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2090856 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2090986 | 90 | 75 | 107.7 | 88.8 | 72.5 | 79 | 71 | 90 mmø | 0.000378606 | FUSAPEX Reduzierstück 110 - 90 | 4007360403003 | 12036071001 | https://oxomi.com/p/3000126/datasheet/-/12036071001 | 0.485
2091032 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2091105 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2091149 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2091191 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2091247 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203

# IfcPipeFitting: FUSAPEX reducer for T-Piece:R (4)
In: Level 1
Type - Material: Warning, PE-Xa white
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX reducer for T-Piece; T1: FUSAPEX reducer; T2: FUSAPEX reducer DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: R
Type - Materials and Finishes - Mat. Coupling: PE-Xa white
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX reducer for T-Piece:R; sets with these values: 2
Other - Family: FUSAPEX reducer for T-Piece; Family and Type: FUSAPEX reducer for T-Piece: R; Type: R; Type Id: 2095353; IsCustom: yes
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 0 mm
Dimensions - Area: 0.00281399 m2; DN1: 125 mm; DoF1: 158 mm; ID1: 130.8 mm; L1: 95 mm; Maximum Size: 125 mm; Minimum Size: 125 mm; Size: 125 mmø; Volume: 0.00000857912 m3
Identity Data - Sorting: 0; ETIM Class code: EC003025; PID: -; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - patented current efficient construction in compact design - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - pressure: 6 bar Materiaal: - PE-X Kleur: - Natural
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 125 mmø
Name (FUSAPEX reducer for T-Piece:R:...) | DN2 (mm) | ID2 (mm) | L2 (mm) | Description long | GTIN | Product URL | Weight
2002591 | 75 | 73.6 | 71 | FUSAPEX Reduzierstück 160 - 90 | 4007360403058 | https://oxomi.com/p/3000126/datasheet/-/12036161001 | 1.23
2002936 | 90 | 90 | 79 | FUSAPEX Reduzierstück 160 - 110 | 4007360403065 | https://oxomi.com/p/3000126/datasheet/-/12036171001 | 1.222
2090289 | 75 | 73.6 | 71 | FUSAPEX Reduzierstück 160 - 90 | 4007360403058 | https://oxomi.com/p/3000126/datasheet/-/12036161001 | 1.23
2090301 | 90 | 90 | 79 | FUSAPEX Reduzierstück 160 - 110 | 4007360403065 | https://oxomi.com/p/3000126/datasheet/-/12036171001 | 1.222

# IfcPipeFitting: FUSAPEX reducer:R (18)
In: Level 1
Type - Material: PE-Xa white
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX reducer; T1: FUSAPEX reducer; T2: FUSAPEX reducer DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: R
Type - Materials and Finishes - Mat. Coupling: PE-Xa white
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX reducer:R; sets with these values: 2
Other - IsCustom: no; Type: R; Family: FUSAPEX reducer; Family and Type: FUSAPEX reducer: R; Type Id: 2098682
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - patented current efficient construction in compact design - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - pressure: 6 bar Materiaal: - PE-X Kleur: - Natural
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX reducer:R:...) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product URL | Weight
2098874 | 50 | 40 | 61.1 | 50.5 | 40 | 57 | 49 | 50 mmø-40 mmø | 0.000090293 | FUSAPEX Reduzierstück 63 - 50 | 4007360488468 | 12143981001 | https://oxomi.com/p/3000126/datasheet/-/12143981001 | 0.29
2099116 | 65 | 40 | 72.8 | 60.5 | 40 | 61 | 49 | 65 mmø-40 mmø | 0.000127087 | FUSAPEX Reduzierstück 75 - 50 | 4007360488475 | 12143991001 | https://oxomi.com/p/3000126/datasheet/-/12143991001 | 0.29
2099224 | 65 | 50 | 72.8 | 60.5 | 50.5 | 61 | 57 | 65 mmø-50 mmø | 0.000141264 | FUSAPEX Reduzierstück 75 - 63 | 4007360488482 | 12144011001 | https://oxomi.com/p/3000126/datasheet/-/12144011001 | 0.29
2099296 | 75 | 40 | 87.7 | 73 | 40 | 71 | 49 | 75 mmø-40 mmø | 0.000207559 | FUSAPEX Reduzierstück 90 - 50 | 4007360488499 | 12144021001 | https://oxomi.com/p/3000126/datasheet/-/12144021001 | 0.29
2099302 | 75 | 50 | 87.7 | 73 | 50.5 | 71 | 57 | 75 mmø-50 mmø | 0.000212894 | FUSAPEX Reduzierstück 90 - 63 | 4007360488505 | 12144031001 | https://oxomi.com/p/3000126/datasheet/-/12144031001 | 0.29
2099399 | 75 | 65 | 87.7 | 72.5 | 60.5 | 71 | 61 | 75 mmø-65 mmø | 0.000222481 | FUSAPEX Reduzierstück 90 - 75 | 4007360402983 | 12036041001 | https://oxomi.com/p/3000126/datasheet/-/12036041001 | 0.29
2099449 | 90 | 40 | 107.7 | 88.8 | 40 | 79 | 49 | 90 mmø-40 mmø | 0.000323744 | FUSAPEX Reduzierstück 110 - 50 | 4007360488512 | 12144051001 | https://oxomi.com/p/3000126/datasheet/-/12144051001 | 0.29
2099455 | 90 | 50 | 107.7 | 88.8 | 50.5 | 79 | 57 | 90 mmø-50 mmø | 0.000337869 | FUSAPEX Reduzierstück 110 - 63 | 4007360488529 | 12144061001 | https://oxomi.com/p/3000126/datasheet/-/12144061001 | 0.29
2099461 | 90 | 65 | 107.7 | 88.8 | 60.5 | 79 | 61 | 90 mmø-65 mmø | 0.000329073 | FUSAPEX Reduzierstück 110 - 75 | 4007360402990 | 12036051001 | https://oxomi.com/p/3000126/datasheet/-/12036051001 | 0.464
2099586 | 90 | 75 | 107.7 | 88.8 | 72.5 | 79 | 71 | 90 mmø-75 mmø | 0.000378606 | FUSAPEX Reduzierstück 110 - 90 | 4007360403003 | 12036071001 | https://oxomi.com/p/3000126/datasheet/-/12036071001 | 0.485
2099691 | 100 | 40 | 122.6 | 101.7 | 40 | 83 | 49 | 100 mmø-40 mmø | 0.000423819 | FUSAPEX Reduzierstück 125 - 50 | 4007360488536 | 12144071001 | https://oxomi.com/p/3000126/datasheet/-/12144071001 | 0.29
2099697 | 100 | 50 | 122.6 | 101.7 | 50.5 | 83 | 57 | 100 mmø-50 mmø | 0.000445901 | FUSAPEX Reduzierstück 125 - 63 | 4007360488543 | 12144081001 | https://oxomi.com/p/3000126/datasheet/-/12144081001 | 0.29
2099703 | 100 | 65 | 122.6 | 101.7 | 61 | 83 | 61 | 100 mmø-65 mmø | 0.000455094 | FUSAPEX Reduzierstück 125 - 75 | 4007360403034 | 12036081001 | https://oxomi.com/p/3000126/datasheet/-/12036081001 | 0.658
2099709 | 100 | 75 | 122.6 | 101.7 | 73 | 83 | 71 | 100 mmø-75 mmø | 0.00049148 | FUSAPEX Reduzierstück 125 - 90 | 4007360403027 | 12036111001 | https://oxomi.com/p/3000126/datasheet/-/12036111001 | 0.658
2099803 | 100 | 90 | 122.6 | 100.7 | 88.6 | 83 | 79 | 100 mmø-90 mmø | 0.000562579 | FUSAPEX Reduzierstück 125 - 110 | 4007360403010 | 12036141001 | https://oxomi.com/p/3000126/datasheet/-/12036141001 | 0.66
2099894 | 110 | 100 | 138 | 114 | 102.1 | 90 | 83 | 110 mmø-100 mmø | 0.000790049 | FUSAPEX Reduzierstück 140 - 125 | 4064299512411 | 12144091001 | https://oxomi.com/p/3000126/datasheet/-/12144091001 | 0.814
2100236 | 125 | 100 | 158 | 130.8 | 102.2 | 95 | 83 | 125 mmø-100 mmø | 0.000961891 | FUSAPEX Reduzierstück 160 - 125 | 4007360403072 | 12036181001 | https://oxomi.com/p/3000126/datasheet/-/12036181001 | 1.203
2100396 | 125 | 110 | 158 | 130.8 | 114.6 | 95 | 90 | 125 mmø-110 mmø | 0.00104753 | FUSAPEX Reduzierstück 160 - 140 | 4064299512428 | 12144971001 | https://oxomi.com/p/3000126/datasheet/-/12144971001 | 1.123

# IfcPipeFitting: FUSAPEX reducer:R (3)
In: Level 1
Type - Material: Warning, PE-Xa white
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX reducer; T1: FUSAPEX reducer; T2: FUSAPEX reducer DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: R
Type - Materials and Finishes - Mat. Coupling: PE-Xa white
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FUSAPEX reducer:R; sets with these values: 2
Other - Type: R; IsCustom: yes; Family: FUSAPEX reducer; Family and Type: FUSAPEX reducer: R; Type Id: 2098682
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 0 mm
Dimensions - Area: 0.00281399 m2; DN1: 125 mm; DoF1: 158 mm; ID1: 130.8 mm; L1: 95 mm; Maximum Size: 125 mm; Volume: 0.00000857912 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; PID: -; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Eigenschap: - patented current efficient construction in compact design - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - pressure: 6 bar Materiaal: - PE-X Kleur: - Natural
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX reducer:R:...) | DN2 (mm) = Minimum Size (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | Description long | GTIN | Product URL | Weight
2100037 | 65 | 61.4 | 63 | 125 mmø-65 mmø | FUSAPEX Reduzierstück 160 - 75 | 4007360403041 | https://oxomi.com/p/3000126/datasheet/-/12036151001 | 1.255
2100152 | 75 | 73.6 | 71 | 125 mmø-75 mmø | FUSAPEX Reduzierstück 160 - 90 | 4007360403058 | https://oxomi.com/p/3000126/datasheet/-/12036161001 | 1.23
2100193 | 90 | 90 | 79 | 125 mmø-90 mmø | FUSAPEX Reduzierstück 160 - 110 | 4007360403065 | https://oxomi.com/p/3000126/datasheet/-/12036171001 | 1.222

# IfcPipeFitting: Female adapter internal thread SDR11:Female adapter LX (7)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Female adapter internal thread SDR11; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Female adapter SDR11 LX; T2: Female adapter SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: Industrierohrsysteme; REHAU Info: 2025.03.27-419114-419114; Type Name: Female adapter LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Female adapter internal thread SDR11:Female adapter LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Female adapter internal thread SDR11; Family and Type: Female adapter internal thread SDR11: Female adapter LX; Type: Female adapter LX; Type Id: 1082534
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass Kleur: - brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Female adapter internal thread SDR11:Female adapter LX:...) | A (deg) | DN1 (mm) | DN2 (mm) | HD1 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1153946 | 45 | 15 | 15 | 8.5 | 13.6 | 18.7 | 15 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000114042 | 16.5 | 7.7 | REHAU Übergang SDR 11 LX 20 - Rp 1/2 | 4007360456931 | 11690991001 | https://oxomi.com/p/3000126/datasheet/-/11690991001 | 0.079
1153962 | 45 | 15 | 20 | 9.6 | 13.6 | 24.3 | 20 | 15 | 20 mmø-15 mmø | 34 | 17 | 0.0000154885 | 18.6 | 7.1 | REHAU Übergang SDR 11 LX 20 - Rp 3/4 | 4007360456948 | 11691001001 | https://oxomi.com/p/3000126/datasheet/-/11691001001 | 0.11
1153968 | 45 | 20 | 20 | 9 | 17.8 | 24.3 | 20 | 20 | 20 mmø-20 mmø | 34 | 17 | 0.0000182384 | 17.2 | 8.3 | REHAU Übergang SDR 11 LX 25 - Rp 3/4 | 4007360457020 | 11691071001 | https://oxomi.com/p/3000126/datasheet/-/11691071001 | 0.12
1153974 | 45 | 20 | 25 | 11 | 17.8 | 30.4 | 25 | 20 | 25 mmø-20 mmø | 41 | 20.5 | 0.0000266601 | 18.6 | 9.8 | REHAU Übergang SDR 11 LX 25 - Rp 1 | 4007360457013 | 11691061001 | https://oxomi.com/p/3000126/datasheet/-/11691061001 | 0.2
1153980 | 45 | 25 | 15 | 2.9 | 22.4 | 18.7 | 25 | 15 | 25 mmø-15 mmø | 27 | 13.5 | 0.0000196683 | 8.9 | 13.3 | REHAU Übergang SDR 11 LX 32 - Rp 1/2 | 4061264941900 | 11691911001 | https://oxomi.com/p/3000126/datasheet/-/11691911001 | 0.124
1153986 | 45 | 25 | 25 | 11.4 | 22.4 | 30.4 | 25 | 25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000308852 | 19.3 | 8 | REHAU Übergang SDR 11 LX 32 - Rp 1 | 4007360457044 | 11691101001 | https://oxomi.com/p/3000126/datasheet/-/11691101001 | 0.18
1153992 | 60 | 32 | 15 | 2 | 27.5 | 18.8 | 32 | 15 | 32 mmø-15 mmø | 27 | 13.5 | 0.0000321786 | 8.6 | 14.2 | REHAU Übergang SDR 11 LX 40 - Rp 1/2 | 4061264935787 | 11691901001 | https://oxomi.com/p/3000126/datasheet/-/11691901001 | 0.23

# IfcPipeFitting: Male adapter external thread SDR11:Male adapter LX (9)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Male adapter external thread SDR11; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Male adapter SDR11 LX; T2: Male adapter SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: Industrierohrsysteme; REHAU Info: 2025.03.31-419114-419114; Type Name: Male adapter LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Male adapter external thread SDR11:Male adapter LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Male adapter external thread SDR11; Family and Type: Male adapter external thread SDR11: Male adapter LX; Type: Male adapter LX; Type Id: 1085458
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Male adapter external thread SDR11:Male adapter LX:...) | A (deg) | DN1 (mm) | DN2 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1154169 | 60 | 15 | 15 | 13.6 | 13.6 | 15 | 15 | 15 mmø-15 mmø | 26 | 13 | 0.000013465 | 7.9 | 13.9 | REHAU Übergang SDR 11 LX 20 - R 1/2 | 4007360456917 | 11690971001 | https://oxomi.com/p/3000126/datasheet/-/11690971001 | 0.066
1154175 | 45 | 15 | 20 | 13.6 | 18 | 20 | 15 | 20 mmø-15 mmø | 28 | 14 | 0.000012193 | 14 | 6.5 | REHAU Übergang SDR 11 LX 20 - R 3/4 | 4007360456924 | 11690981001 | https://oxomi.com/p/3000126/datasheet/-/11690981001 | 0.086
1154181 | 60 | 20 | 20 | 17.8 | 17.8 | 20 | 20 | 20 mmø-20 mmø | 34 | 17 | 0.0000229199 | 7.9 | 14.4 | REHAU Übergang SDR 11 LX 25 - R 3/4 | 4007360457006 | 11691051001 | https://oxomi.com/p/3000126/datasheet/-/11691051001 | 0.11
1154187 | 45 | 20 | 25 | 17.8 | 24 | 25 | 20 | 25 mmø-20 mmø | 31 | 15.5 | 0.0000171695 | 14 | 6.7 | REHAU Übergang SDR 11 LX 25 - R 1 | 4007360456993 | 11691041001 | https://oxomi.com/p/3000126/datasheet/-/11691041001 | 0.131
1154193 | 45 | 25 | 25 | 22.4 | 24 | 25 | 25 | 25 mmø-25 mmø | 40 | 20 | 0.0000267134 | 15 | 6.7 | REHAU Übergang SDR 11 LX 32 - R 1 | 4007360457037 | 11691091001 | https://oxomi.com/p/3000126/datasheet/-/11691091001 | 0.171
1154199 | 60 | 32 | 32 | 27.5 | 30.5 | 32 | 32 | 32 mmø-32 mmø | 36 | 18 | 0.0000551991 | 8.7 | 18.3 | REHAU Übergang SDR 11 LX 40 - R 1 1/4 | 4007360457051 | 11691111001 | https://oxomi.com/p/3000126/datasheet/-/11691111001 | 0.35
1154205 | 60 | 40 | 32 | 35.5 | 30.5 | 40 | 32 | 40 mmø-32 mmø | 41 | 20.5 | 0.0000723169 | 8.7 | 19.3 | REHAU Übergang mit AG, SDR 11 LX 50 - R 1 1/4 | 4007360457921 | 11691491001 | https://oxomi.com/p/3000126/datasheet/-/11691491001 | 0.48
1154211 | 60 | 40 | 40 | 35.5 | 36 | 40 | 40 | 40 mmø-40 mmø | 41 | 20.5 | 0.0000754024 | 8.8 | 18 | REHAU Übergang mit AG, SDR 11 LX 50 - R 1 1/2 | 4007360458140 | 11691431001 | https://oxomi.com/p/3000126/datasheet/-/11691431001 | 0.51
1154217 | 60 | 50 | 50 | 45.5 | 45.5 | 50 | 50 | 50 mmø-50 mmø | 55 | 27.5 | 0.000133181 | 12.2 | 20.2 | REHAU Übergang mit AG, SDR 11 LX 63 - R 2 | 4007360457860 | 11691411001 | https://oxomi.com/p/3000126/datasheet/-/11691411001 | 0.8

# IfcPipeFitting: Male adapter external thread SDR11:Male adapter RX (4)
In: Level 1
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; Family Name: Male adapter external thread SDR11; Max sleeve: 50 mm; T1: Male adapter SDR11 LX; T2: Male adapter SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: RX11; Manufacturer: REHAU; Model: Industrierohrsysteme; REHAU Info: 2025.03.31-419114-419114; Type Name: Male adapter RX
Type - Materials and Finishes - Mat. Coupling: RAUTITAN RX+
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Male adapter external thread SDR11:Male adapter RX; sets with these values: 2
Other - A: 60 deg; IsCustom: no; Sleeve DN1: Sleeve : RX 11; Sleeve DN2: Sleeve : RX 11; Family: Male adapter external thread SDR11; Family and Type: Male adapter external thread SDR11: Male adapter RX; Type: Male adapter RX; Type Id: 1157380
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Male adapter external thread SDR11:Male adapter RX:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1154223 | 65 | 54 | 65 | 65 mmø-65 mmø | 73 | 36.5 | 0.000201285 | 9.5 | 17.9 | REHAU Übergang mit AG, SDR 11 RX 75 - R 2 1/2 | 4007360113902 | 12675811001 | https://oxomi.com/p/3000126/datasheet/-/12675811001 | 1.66
1154229 | 75 | 69 | 76 | 75 mmø-75 mmø | 90 | 45 | 0.000272328 | 9.5 | 15.6 | REHAU Übergang mit AG, SDR 11 RX 90 - R 3 | 4007360113919 | 12675911001 | https://oxomi.com/p/3000126/datasheet/-/12675911001 | 2.11
1154235 | 90 | 83 | 100 | 90 mmø-90 mmø | 110 | 55 | 0.000453904 | 9.2 | 17.9 | REHAU Übergang mit AG, SDR 11 RX 110 - R 4 | 4007360113926 | 12676011001 | https://oxomi.com/p/3000126/datasheet/-/12676011001 | 3.9
1154241 | 100 | 90 | 120 | 100 mmø-100 mmø | 120 | 60 | 0.000674339 | 7.5 | 25 | REHAU Übergang mit AG, SDR 11 RX 125 - R 5 | 4007360218331 | 12352391001 | https://oxomi.com/p/3000126/datasheet/-/12352391001 | 5.2

# IfcPipeFitting: Sleeve:LX 11 (261)
In: Level 1
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: LX 11; Manufacturer: REHAU; Model: LX 11; REHAU Info: 14.02.2024-420668-420668; Type Name: LX 11
Type - Materials and Finishes - Mat. Error: Error; Mat. Sleeve: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Sleeve:LX 11; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: LX 11; T1: Sleeve DN; Type: LX 11; Type Id: 1027698
Constraints - Level: Level 1; Moves With Nearby Elements: no
Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:LX 11:...) | Elevation from Level (mm) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1086954 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1088178 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1088301 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1088305 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1092398 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1092404 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1092410 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1092416 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1092422 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1092428 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1092434 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1092440 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1093295 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1093407 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1093487 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1098982 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1098983 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1099158 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1099159 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1099228 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1099229 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1099296 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1099297 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1099368 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1099369 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1099450 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1099451 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1119055 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1119056 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1119085 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1119086 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1119093 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1119094 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1119101 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1119102 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1119109 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1119110 | 0 | 40 | 44 | 0.0000347836 | REHAU compression sleeve, SDR 11 LX 50 x 4.6 | 4007360055516 | 11386931001 | 5691 | https://oxomi.com/p/3000126/datasheet/-/11386931001 | 0.26
1119117 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1119118 | 0 | 50 | 53 | 0.0000515303 | REHAU compression sleeve, SDR 11 LX 63 x 5.8 | 4007360055523 | 11387031001 | 5692 | https://oxomi.com/p/3000126/datasheet/-/11387031001 | 0.39
1134569 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1134575 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1134581 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1134587 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1134872 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1142761 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
1142908 | 0 | 32 | 37 | 0.0000182658 | REHAU Compression sleeve, SDR 11 LX 40 x 3.7 | 4007360055509 | 11386831001 | 5690 | https://oxomi.com/p/3000126/datasheet/-/11386831001 | 0.131
1143592 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1143593 | 0 | 15 | 20 | 0.00000289013 | REHAU Compression sleeve, SDR 11 LX 20 x 1.9/2.0 | 4007360038892 | 11395621001 | 5687 | https://oxomi.com/p/3000126/datasheet/-/11395621001 | 0.0218
1143600 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1143601 | 0 | 20 | 27 | 0.00000485992 | REHAU Compression sleeve, SDR 11 LX 25 x 2.3 | 4007360038908 | 11395721001 | 5688 | https://oxomi.com/p/3000126/datasheet/-/11395721001 | 0.04
1143608 | 0 | 25 | 35 | 0.0000129535 | REHAU Compression sleeve, SDR 11 LX 32 x 2.9 | 4007360038915 | 11394921001 | 5689 | https://oxomi.com/p/3000126/datasheet/-/11394921001 | 0.08
