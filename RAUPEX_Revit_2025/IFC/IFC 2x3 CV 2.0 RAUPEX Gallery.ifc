Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcFlowFitting: Coupling union:C EQ SDR11 LX (6)
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Coupling union:C EQ SDR11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; V1: yes; V2: no; Family: Coupling union; Family and Type: Coupling union: C EQ SDR11 LX; Type: C EQ SDR11 LX; Type Id: 1077083
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Coupling union:C EQ SDR11 LX:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1119054 | 15 | 13.6 | 15 mmø-15 mmø | 0.0000073773 | 11 | REHAU Kupplung SDR 11 LX 20 - 20 | 4007360456023 | 11690081001 | https://oxomi.com/p/3000126/datasheet/-/11690081001 | 0.062
1119084 | 20 | 17.8 | 20 mmø-20 mmø | 0.0000109752 | 11 | REHAU Kupplung SDR 11 LX 25 - 25 | 4007360456252 | 11690101001 | https://oxomi.com/p/3000126/datasheet/-/11690101001 | 0.093
1119092 | 25 | 22.4 | 25 mmø-25 mmø | 0.0000230793 | 12 | REHAU Kupplung SDR 11 LX 32 - 32 | 4007360456221 | 11690131001 | https://oxomi.com/p/3000126/datasheet/-/11690131001 | 0.177
1119100 | 32 | 27.5 | 32 mmø-32 mmø | 0.0000493124 | 19 | REHAU Kupplung SDR 11 LX 40 - 40 | 4007360456207 | 11690151001 | https://oxomi.com/p/3000126/datasheet/-/11690151001 | 0.38
1119108 | 40 | 35.5 | 40 mmø-40 mmø | 0.0000748666 | 20.4 | REHAU Kupplung, SDR 11 LX 50 - 50 | 4007360457877 | 11691441001 | https://oxomi.com/p/3000126/datasheet/-/11691441001 | 0.57
1119116 | 50 | 45.5 | 50 mmø-50 mmø | 0.000124197 | 23.5 | REHAU Kupplung, SDR 11 LX 63 - 63 | 4007360458133 | 11691421001 | https://oxomi.com/p/3000126/datasheet/-/11691421001 | 0.94

# IfcFlowFitting: Coupling union:C EQ SDR11 RX (6)
In: Level 1
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; Family Name: Coupling union; Max sleeve: 50 mm; T1: Coupling union; T2: Coupling union DN1+DN2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: RX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: C EQ SDR11 RX
Type - Materials and Finishes - Mat. Coupling: RAUTITAN RX+
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Coupling union:C EQ SDR11 RX; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: Coupling union; Family and Type: Coupling union: C EQ SDR11 RX; Sleeve DN1: Sleeve : RX 11; Sleeve DN2: Sleeve : RX 11; Type: C EQ SDR11 RX; Type Id: 1077081
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Coupling union:C EQ SDR11 RX:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1119124 | 65 | 54 | 65 mmø-65 mmø | 0.000200829 | 15.8 | REHAU Kupplung, SDR 11 RX 75 - 75 | 4007360113933 | 12676111001 | https://oxomi.com/p/3000126/datasheet/-/12676111001 | 1.78
1119132 | 75 | 69 | 75 mmø-75 mmø | 0.000266087 | 15.8 | REHAU Kupplung, SDR 11 RX 90 - 90 | 4007360113940 | 12676211001 | https://oxomi.com/p/3000126/datasheet/-/12676211001 | 2.21
1119140 | 90 | 83 | 90 mmø-90 mmø | 0.000417853 | 15.8 | REHAU Kupplung, SDR 11 RX 110 - 110 | 4007360113957 | 12676311001 | https://oxomi.com/p/3000126/datasheet/-/12676311001 | 3.12
1119148 | 100 | 90 | 100 mmø-100 mmø | 0.00049377 | 31.5 | REHAU Kupplung, SDR 11 RX 125 - 125 | 4007360218317 | 12352191001 | https://oxomi.com/p/3000126/datasheet/-/12352191001 | 4.5
1119164 | 125 | 116 | 125 mmø-125 mmø | 0.000937615 | 36.5 | REHAU Kupplung, SDR 11 RX 160 - 160 | 4007360218287 | 12343341001 | https://oxomi.com/p/3000126/datasheet/-/12343341001 | 5.5
1491241 | 110 | 101 | 110 mmø-110 mmø | 0.0007163 | 34 | REHAU Kupplung, SDR 11 RX 140 - 140 | 4007360469658 | 12062571001 | https://oxomi.com/p/3000126/datasheet/-/12062571001 | 5

# IfcFlowFitting: Elbow SDR11 LX:Elbow SDR 11 LX (11)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Elbow SDR11 LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Elbow SDR11 LX; T2: Elbow SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Elbow SDR 11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Elbow SDR11 LX:Elbow SDR 11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Elbow SDR11 LX; Family and Type: Elbow SDR11 LX: Elbow SDR 11 LX; Type: Elbow SDR 11 LX; Type Id: 1072047
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Elbow SDR11 LX:Elbow SDR 11 LX:...) | Angle check (deg) = Angle (deg) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight | System Classification
1143591 | 90 | 15 | 20 | 13.6 | 43.5 | 15 mmø-15 mmø | 4.7 | 0.0000141948 | 28.5 | REHAU Winkel SDR 11 LX 20 - 20, 90 Grad | 4007360457143 | 11691241001 | https://oxomi.com/p/3000126/datasheet/-/11691241001 | 0.107 | Undefined
1143599 | 90 | 20 | 25 | 17.8 | 52.5 | 20 mmø-20 mmø | 3.7 | 0.0000223641 | 31 | REHAU Winkel SDR 11 LX 25 - 25, 90 Grad | 4007360457167 | 11691261001 | https://oxomi.com/p/3000126/datasheet/-/11691261001 | 0.16 | Undefined
1143607 | 90 | 25 | 32 | 22.4 | 63 | 25 mmø-25 mmø | 4.5 | 0.0000454527 | 36 | REHAU Winkel SDR 11 LX 32 - 32, 90 Grad | 4007360457181 | 11691281001 | https://oxomi.com/p/3000126/datasheet/-/11691281001 | 0.26 | Undefined
1143615 | 90 | 32 | 40 | 27.5 | 75.2 | 32 mmø-32 mmø | 6.5 | 0.0000924596 | 43.2 | REHAU Winkel SDR 11 LX 40 - 40, 90 Grad | 4007360457204 | 11691301001 | https://oxomi.com/p/3000126/datasheet/-/11691301001 | 0.52 | Undefined
1143623 | 90 | 40 | 50 | 35.5 | 87.5 | 40 mmø-40 mmø | 6.7 | 0.000154344 | 48.5 | REHAU Winkel SDR 11 LX 50 - 50, 90 Grad | 4007360457884 | 11691451001 | https://oxomi.com/p/3000126/datasheet/-/11691451001 | 0.82 | Undefined
1143631 | 90 | 50 | 63 | 44 | 106 | 50 mmø-50 mmø | 8.9 | 0.000289525 | 55.3 | REHAU Winkel SDR 11 LX 63 - 63, 90 Grad | 4007360457891 | 11691461001 | https://oxomi.com/p/3000126/datasheet/-/11691461001 | 1.5 | Undefined
1173711 | 45 | 20 | 25 | 17.8 | 52.5 | 20 mmø-20 mmø | 3.7 | 0.000022364 | 31 | REHAU Winkel SDR 11 LX 25 - 25, 45 Grad | 4007360457150 | 11691251001 | https://oxomi.com/p/3000126/datasheet/-/11691251001 | 0.137 | Undefined
1173717 | 45 | 25 | 32 | 22.4 | 63 | 25 mmø-25 mmø | 4.5 | 0.0000454525 | 36 | REHAU Winkel SDR 11 LX 32 - 32, 45 Grad | 4007360457174 | 11691271001 | https://oxomi.com/p/3000126/datasheet/-/11691271001 | 0.259 | Domestic Cold Water | Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 56; Group: Domestic Cold Water 56
1173723 | 45 | 32 | 40 | 27.5 | 75.2 | 32 mmø-32 mmø | 6.5 | 0.0000924593 | 43.2 | REHAU Winkel SDR 11 LX 40 - 40, 45 Grad | 4007360457198 | 11691291001 | https://oxomi.com/p/3000126/datasheet/-/11691291001 | 0.457 | Undefined
1173729 | 45 | 40 | 50 | 35.5 | 87.5 | 40 mmø-40 mmø | 6.7 | 0.000154343 | 48.5 | REHAU Winkel SDR 11 LX 50 - 50, 45 Grad | 4007360457211 | 11691311001 | https://oxomi.com/p/3000126/datasheet/-/11691311001 | 0.7 | Undefined
1173735 | 45 | 50 | 63 | 44 | 106 | 50 mmø-50 mmø | 8.9 | 0.000289525 | 55.3 | REHAU Winkel SDR 11 LX 63 - 63, 45 Grad | 4007360457938 | 11691501001 | https://oxomi.com/p/3000126/datasheet/-/11691501001 | 1.305 | Undefined

# IfcFlowFitting: Elbow SDR11 LX:Elbow SDR 11 RX (4)
In: Level 1
Type - Material: RX
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; Family Name: Elbow SDR11 LX; Max sleeve: 50 mm; T1: Elbow SDR11 LX; T2: Elbow SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: RX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Elbow SDR 11 RX
Type - Materials and Finishes - Mat. Coupling: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Elbow SDR11 LX:Elbow SDR 11 RX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : RX 11; Sleeve DN2: Sleeve : RX 11; Family: Elbow SDR11 LX; Family and Type: Elbow SDR11 LX: Elbow SDR 11 RX; Type: Elbow SDR 11 RX; Type Id: 1072049
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass LX or red brass RX Kleur: - Brass and red brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Elbow SDR11 LX:Elbow SDR 11 RX:...) | Angle check (deg) = Angle (deg) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1173556 | 90 | 65 | 75 | 54 | 116.5 | 65 mmø-65 mmø | 9.4 | 0.000421307 | 66 | REHAU Winkel SDR 11 RX 75 - 75, 90 Grad | 4007360202040 | 12677511001 | https://oxomi.com/p/3000126/datasheet/-/12677511001 | 2.44
1173562 | 90 | 75 | 90 | 68 | 125.5 | 75 mmø-75 mmø | 9.2 | 0.000630272 | 75.1 | REHAU Winkel SDR 11 RX 90 - 90, 90 Grad | 4007360202125 | 12677611001 | https://oxomi.com/p/3000126/datasheet/-/12677611001 | 3.33
1173592 | 90 | 90 | 110 | 83 | 136.5 | 90 mmø-90 mmø | 8.9 | 0.00100617 | 85.8 | REHAU Winkel SDR 11 RX 110 x 110, 90 Grad | 4007360202132 | 12677711001 | https://oxomi.com/p/3000126/datasheet/-/12677711001 | 5.01
1173920 | 45 | 65 | 75 | 54 | 116.5 | 65 mmø-65 mmø | 9.4 | 0.000421305 | 66 | REHAU Winkel SDR 11 RX 75 - 75, 45 Grad | 4007360195854 | 12378361001 | https://oxomi.com/p/3000126/datasheet/-/12378361001 | 1.72

# IfcFlowFitting: Elbow adapter SDR11 LX:Elbow adapter SDR 11 LX (5)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Elbow adapter SDR11 LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Elbow adapter SDR11 LX; T2: Elbow adapter SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Elbow adapter SDR 11 LX
Type - Materials and Finishes - Mat. coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Elbow adapter SDR11 LX:Elbow adapter SDR 11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Elbow adapter SDR11 LX; Family and Type: Elbow adapter SDR11 LX: Elbow adapter SDR 11 LX; Type: Elbow adapter SDR 11 LX; Type Id: 1079686
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass Kleur: - brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Elbow adapter SDR11 LX:Elbow adapter SDR 11 LX:...) | Type 0 | Type 1 | A (deg) | C (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | SLW 2 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1134568 | no | yes | 60 | 6.5 | 15 | 15 | 17.6 | 17.5 | 13.6 | 13.5 | 39.8 | 33.5 | 15 mmø-15 mmø | 23 | 11.5 | 4.7 | 0.0000114731 | 25 | 20.3 | REHAU Winkelübergang SDR 11 LX 20 - R 1/2 | 4007360457280 | 11691381001 | https://oxomi.com/p/3000126/datasheet/-/11691381001 | 0.095
1134574 | yes | no | 45 | 6.3 | 15 | 20 | 17.6 | 19 | 13.6 | 19 | 43 | 34.8 | 20 mmø-15 mmø | 29 | 14.5 | 4.8 | 0.0000125303 | 28 | 20.2 | REHAU Winkelübergang SDR 11 LX 20 - R 3/4 | 4007360457297 | 11691391001 | https://oxomi.com/p/3000126/datasheet/-/11691391001 | 0.115
1134580 | yes | no | 45 | 6.4 | 20 | 20 | 22 | 22.8 | 17.8 | 19 | 49.5 | 37.5 | 20 mmø-20 mmø | 29 | 14.5 | 3.6 | 0.0000169583 | 28 | 23 | REHAU Winkelübergang SDR 11 LX 25 - R 3/4 | 4007360457303 | 11691401001 | https://oxomi.com/p/3000126/datasheet/-/11691401001 | 0.18
1134586 | no | yes | 60 | 7 | 25 | 25 | 27.9 | 28.8 | 22.4 | 24 | 65 | 35.8 | 25 mmø-25 mmø | 34 | 17 | 4.5 | 0.0000304933 | 38 | 19 | REHAU Winkelübergang SDR 11 LX 32 - R 1 | 4007360488024 | 11690261001 | https://oxomi.com/p/3000126/datasheet/-/11690261001 | 0.198
1134871 | yes | no | 45 | 7.5 | 32 | 32 | 36 | 41.4 | 27.5 | 32.5 | 74.5 | 37.1 | 32 mmø-32 mmø | 43 | 21.5 | 6.5 | 0.00006094 | 42.5 | 18 | REHAU Winkelübergang SDR 11 LX 40 - R 1 1/4 | 4061264941917 | 11691831001 | https://oxomi.com/p/3000126/datasheet/-/11691831001 | 0.198

# IfcFlowFitting: Elbow adapter with union nut SDR11 LX :Elbow adapter with union nut SDR 11 LX (2)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Elbow adapter with union nut SDR11 LX; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Elbow adapter with union nut SDR11 LX; T2: Elbow adapter with union nut SDR11 LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Elbow adapter with union nut SDR 11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Elbow adapter with union nut SDR11 LX :Elbow adapter with union nut SDR 11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Type 0: no; Type 1: yes; Family: Elbow adapter with union nut SDR11 LX; Family and Type: Elbow adapter with union nut SDR11 LX : Elbow adapter with union nut SDR 11 LX; Type: Elbow adapter with union nut SDR 11 LX; Type Id: 1027781
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - A: 60 deg; Area: 0.00281399 m2; C: 17 mm; DN2: 25 mm; HD2: 2 mm; ID2: 20 mm; LC: 17 mm; Minimum Size: 25 mm; SLW: 38 mm; SLW 2: 19 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Brass Kleur: - brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Elbow adapter with union nut SDR11 LX :Elbow adapter with union nut SDR 11 LX:...) | DN1 (mm) = Maximum Size (mm) | DoF1 (mm) | DoF1/2 (mm) | HD1 (mm) | HD1/2 (mm) | ID1 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1142760 | 25 | 27.9 | 13.95 | 28 | 14 | 22.4 | 63.5 | 45 | 25 mmø-25 mmø | 0.000041662 | 36.5 | 32.7 | REHAU Winkelübergang SDR 11 LX 32 - G1 | 4064299347747 | 11691891001 | https://oxomi.com/p/3000126/datasheet/-/11691891001 | 0.278
1142907 | 32 | 35.8 | 17.9 | 28.1 | 14.05 | 27.5 | 70.5 | 45.8 | 32 mmø-25 mmø | 0.0000627919 | 38.5 | 38 | REHAU Winkelübergang SDR 11 LX 40 - G 1 | 4061264935763 | 11691821001 | https://oxomi.com/p/3000126/datasheet/-/11691821001 | 0.418

# IfcFlowFitting: FUSAPEX 2.0 Elbow:Elbow 2.0 (8)
In: Level 1
Type - Material: FUSAPEX 2.0
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX 2.0 Elbow; T1: FUSAPEX 2.0 Elbow; T2: FUSAPEX 2.0 Elbow DN1-2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; REHAU Info: 2025.07.21-419114-419114; Type Name: Elbow 2.0
Type - Materials and Finishes - Mat. Coupling: FUSAPEX 2.0
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FUSAPEX 2.0 Elbow:Elbow 2.0; sets with these values: 2
Other - IsCustom: no; Angle check: 90 deg; Family: FUSAPEX 2.0 Elbow; Family and Type: FUSAPEX 2.0 Elbow: Elbow 2.0; Type: Elbow 2.0; Type Id: 1693786
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 90 deg; Area: 0.00281399 m2; HD1: 17 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003024; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for FUSAPEX reducers and flange transitions Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 - automatic recognition of welding parameters using SMARTFUSE technology Kleur: - Orange Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX 2.0 Elbow:Elbow 2.0:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Do2 (mm) | DoF1 (mm) = ID1 (mm) = ID2 (mm) | HD2 (mm) | HD3 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1693803 | 40 | 68 | 34 | 50 | 52 | 12.8 | 77.4 | 40 mmø-40 mmø | 0.000276431 | 48 | FUSAPEX 2.0 Winkel 50, 90 Grad, orange | 4062178684877 | 14847111001 | https://oxomi.com/p/3000126/datasheet/-/14847111001 | 0.221
1707071 | 50 | 81 | 40.5 | 63 | 59 | 16 | 94.6 | 50 mmø-50 mmø | 0.000404876 | 55.8 | FUSAPEX 2.0 Winkel 63, 90 Grad, orange | 4062178684884 | 14847121001 | https://oxomi.com/p/3000126/datasheet/-/14847121001 | 0.333
1707080 | 65 | 97 | 48.5 | 75 | 62 | 19.5 | 114.35 | 65 mmø-65 mmø | 0.000700847 | 69.5 | FUSAPEX 2.0 Winkel 75, 90 Grad, orange | 4062178684891 | 14847131001 | https://oxomi.com/p/3000126/datasheet/-/14847131001 | 0.506
1707089 | 75 | 113 | 56.5 | 90 | 69 | 11.3 | 161 | 75 mmø-75 mmø | 0.00131164 | 78 | FUSAPEX 2.0 Winkel 90, 90 Grad, orange | 4062178685300 | 14847141001 | https://oxomi.com/p/3000126/datasheet/-/14847141001 | 0.855
1707100 | 90 | 143 | 71.5 | 110 | 79 | 11.5 | 177 | 90 mmø-90 mmø | 0.00260082 | 79 | FUSAPEX 2.0 Winkel 110, 90 Grad, orange | 4062178676285 | 14847151001 | https://oxomi.com/p/3000126/datasheet/-/14847151001 | 1.522
1707109 | 100 | 165 | 82.5 | 125 | 89 | 14.5 | 195 | 100 mmø-100 mmø | 0.00396248 | 100 | FUSAPEX 2.0 Winkel 125, 90 Grad, orange | 4062178676629 | 14847161001 | https://oxomi.com/p/3000126/datasheet/-/14847161001 | 2.33
1707118 | 110 | 183 | 91.5 | 140 | 94 | 13.5 | 224.8 | 110 mmø-110 mmø | 0.00550036 | 93 | FUSAPEX 2.0 Winkel 140, 90 Grad, orange | 4062178685317 | 14847171001 | https://oxomi.com/p/3000126/datasheet/-/14847171001 | 3.024
1707389 | 125 | 209 | 104.5 | 160 | 106 | 13.6 | 226.9 | 125 mmø-125 mmø | 0.00736534 | 87 | FUSAPEX 2.0 Winkel 160, 90 Grad, orange | 4062178488482 | 14847181001 | https://oxomi.com/p/3000126/datasheet/-/14847181001 | 3.72

# IfcFlowFitting: FUSAPEX 2.0 T-piece:T-Piece 2.0 (31)
In: Level 1
Type - Material: FUSAPEX 2.0
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX 2.0 T-piece; T1: FUSAPEX 2.0 T-piece; T2: FUSAPEX 2.0 T-piece DN1-3; T3: FUSAPEX reducer DN1; T4: FUSAPEX 2.0 T-piece Z2; T5: FUSAPEX 2.0 T-piece Z3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.07.09-419114-419114; Type Name: T-Piece 2.0
Type - Materials and Finishes - Mat. Coupling: FUSAPEX 2.0
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FUSAPEX 2.0 T-piece:T-Piece 2.0; sets with these values: 2
Other - IsCustom: no; Family: FUSAPEX 2.0 T-piece; Family and Type: FUSAPEX 2.0 T-piece: T-Piece 2.0; Type: T-Piece 2.0; Type Id: 1969859
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - HD1: 17 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for FUSAPEX reducers and flange transitions Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 - automatic recognition of welding parameters using SMARTFUSE technology Kleur: - Orange Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX 2.0 T-piece:T-Piece 2.0:...) | Reducer_Visible | Reducer_Visible 2 | Area (m2) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) | DN3 (mm) | DoF1 (mm) | DoF2 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | ID1 (mm) = ID3 (mm) | L1 (mm) | L2 (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Product URL | Weight
1969888 | yes | no | 0.0200633 | 65 | 50 | 65 | 86.4 | 50 | 62 | 18.8 | 54.6 | 74.4 | 98 | 129 | 50 | 65 mmø-65 mmø-50 mmø | 0.000423534 | 35 | 253 | 35 | FUSAPEX 2.0 T-Stück 75 - 75 - 75, orange | 4062178993221 | 14847231001 | https://oxomi.com/p/3000126/datasheet/-/14847231001 | 0.597
1976804 | no | no | 0.0118067 | 40 | 40 | 40 | 61.8 | 50 | 52 | 21.1 | 35.4 | 50 | 69.5 | 102 | 40 | 40 mmø-40 mmø-40 mmø | 0.000158605 | 21.5 | 105 | 21.5 | FUSAPEX 2.0 T-Stück 50 - 50 - 50, orange | 4062178993207 | 14847211001 | https://oxomi.com/p/3000126/datasheet/-/14847211001 | 0.27
1977213 | no | no | 0.0161487 | 50 | 50 | 50 | 73.8 | 50 | 58 | 21.1 | 42.1 | 63 | 83.5 | 119 | 50 | 50 mmø-50 mmø-50 mmø | 0.000287595 | 25.4 | 122 | 25.4 | FUSAPEX 2.0 T-Stück 63 - 63 - 63, orange | 4062178993214 | 14847221001 | https://oxomi.com/p/3000126/datasheet/-/14847221001 | 0.434
1977229 | no | no | 0.0200633 | 65 | 65 | 65 | 86.4 | 50 | 62 | 18.8 | 54.6 | 74.4 | 98 | 129 | 65 | 65 mmø-65 mmø-65 mmø | 0.000423534 | 35 | 132 | 35 | FUSAPEX 2.0 T-Stück 75 - 75 - 75, orange | 4062178993221 | 14847231001 | https://oxomi.com/p/3000126/datasheet/-/14847231001 | 0.597
1977235 | no | no | 0.0253623 | 75 | 75 | 75 | 105.1 | 50 | 71 | 18.45 | 86.3 | 90 | 147 | 137 | 75 | 75 mmø-75 mmø-75 mmø | 0.00062854 | 76 | 140 | 76 | FUSAPEX 2.0 T-Stück 90 - 90 - 90, orange | 4062178993238 | 14847241001 | https://oxomi.com/p/3000126/datasheet/-/14847241001 | 1.115
1977241 | no | no | 0.0352109 | 90 | 90 | 90 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 90 | 90 mmø-90 mmø-90 mmø | 0.00107685 | 92 | 163 | 92 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
1977247 | no | no | 0.043702 | 100 | 100 | 100 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 100 | 100 mmø-100 mmø-100 mmø | 0.00152103 | 105 | 180 | 105 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
1977259 | no | no | 0.0647883 | 125 | 125 | 125 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 125 | 125 mmø-125 mmø-125 mmø | 0.00278853 | 134 | 209.6 | 134 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
1988097 | yes | no | 0.0253623 | 75 | 65 | 75 | 105.1 | 50 | 71 | 18.45 | 86.3 | 90 | 147 | 137 | 65 | 75 mmø-75 mmø-65 mmø | 0.00062854 | 76 | 275 | 76 | FUSAPEX 2.0 T-Stück 90 - 90 - 90, orange | 4062178993238 | 14847241001 | https://oxomi.com/p/3000126/datasheet/-/14847241001 | 1.115
1988497 | yes | no | 0.0352109 | 90 | 65 | 90 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 65 | 90 mmø-90 mmø-65 mmø | 0.00107685 | 92 | 306 | 92 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
2002328 | yes | no | 0.0352109 | 90 | 75 | 90 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 75 | 90 mmø-90 mmø-75 mmø | 0.00107685 | 92 | 316 | 92 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
2002489 | yes | no | 0.043702 | 100 | 75 | 100 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 75 | 100 mmø-100 mmø-75 mmø | 0.00152103 | 105 | 337 | 105 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
2002589 | yes | no | 0.0647883 | 125 | 75 | 125 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 75 | 125 mmø-125 mmø-75 mmø | 0.00278853 | 134 | 378.6 | 134 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2002813 | yes | no | 0.043702 | 100 | 90 | 100 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 90 | 100 mmø-100 mmø-90 mmø | 0.00152103 | 105 | 345 | 105 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
2002934 | yes | no | 0.0647883 | 125 | 90 | 125 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 90 | 125 mmø-125 mmø-90 mmø | 0.00278853 | 134 | 386.6 | 134 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2003131 | yes | no | 0.0647883 | 125 | 100 | 125 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 100 | 125 mmø-125 mmø-100 mmø | 0.00278853 | 134 | 390.6 | 134 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2090231 | yes | yes | 0.0200633 | 65 | 50 | 50 | 86.4 | 50 | 62 | 18.8 | 54.6 | 74.4 | 98 | 129 | 50 | 65 mmø-50 mmø-50 mmø | 0.000423534 | 35 | 253 | 158 | FUSAPEX 2.0 T-Stück 75 - 75 - 75, orange | 4062178993221 | 14847231001 | https://oxomi.com/p/3000126/datasheet/-/14847231001 | 0.597
2090235 | no | yes | 0.0161487 | 50 | 50 | 40 | 73.8 | 50 | 58 | 21.1 | 42.1 | 63 | 83.5 | 119 | 40 | 50 mmø-40 mmø-50 mmø | 0.000287595 | 25.4 | 122 | 135.5 | FUSAPEX 2.0 T-Stück 63 - 63 - 63, orange | 4062178993214 | 14847221001 | https://oxomi.com/p/3000126/datasheet/-/14847221001 | 0.434
2090237 | no | yes | 0.0200633 | 65 | 65 | 50 | 86.4 | 50 | 62 | 18.8 | 54.6 | 74.4 | 98 | 129 | 50 | 65 mmø-50 mmø-65 mmø | 0.000423534 | 35 | 132 | 158 | FUSAPEX 2.0 T-Stück 75 - 75 - 75, orange | 4062178993221 | 14847231001 | https://oxomi.com/p/3000126/datasheet/-/14847231001 | 0.597
2090239 | no | yes | 0.0253623 | 75 | 75 | 65 | 105.1 | 50 | 71 | 18.45 | 86.3 | 90 | 147 | 137 | 65 | 75 mmø-65 mmø-75 mmø | 0.00062854 | 76 | 140 | 211 | FUSAPEX 2.0 T-Stück 90 - 90 - 90, orange | 4062178993238 | 14847241001 | https://oxomi.com/p/3000126/datasheet/-/14847241001 | 1.115
2090241 | no | yes | 0.0352109 | 90 | 90 | 75 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 75 | 90 mmø-75 mmø-90 mmø | 0.00107685 | 92 | 163 | 237 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
2090243 | no | yes | 0.043702 | 100 | 100 | 90 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 90 | 100 mmø-90 mmø-100 mmø | 0.00152103 | 105 | 180 | 273 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
2090245 | no | yes | 0.0647883 | 125 | 125 | 100 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 100 | 125 mmø-100 mmø-125 mmø | 0.00278853 | 134 | 209.6 | 306.3 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2090263 | yes | yes | 0.0253623 | 75 | 65 | 65 | 105.1 | 50 | 71 | 18.45 | 86.3 | 90 | 147 | 137 | 65 | 75 mmø-65 mmø-65 mmø | 0.00062854 | 76 | 275 | 211 | FUSAPEX 2.0 T-Stück 90 - 90 - 90, orange | 4062178993238 | 14847241001 | https://oxomi.com/p/3000126/datasheet/-/14847241001 | 1.115
2090269 | yes | yes | 0.0352109 | 90 | 65 | 65 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 65 | 90 mmø-65 mmø-65 mmø | 0.00107685 | 92 | 306 | 227 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
2090275 | yes | yes | 0.0352109 | 90 | 75 | 75 | 129 | 50 | 81 | 16.5 | 102.3 | 110 | 163 | 160 | 75 | 90 mmø-75 mmø-75 mmø | 0.00107685 | 92 | 316 | 237 | FUSAPEX 2.0 T-Stück 110 - 110 - 110, orange | 4062178993245 | 14847251001 | https://oxomi.com/p/3000126/datasheet/-/14847251001 | 1.965
2090281 | yes | yes | 0.043702 | 100 | 75 | 90 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 75 | 100 mmø-90 mmø-75 mmø | 0.00152103 | 105 | 337 | 273 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
2090287 | yes | yes | 0.0647883 | 125 | 75 | 100 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 75 | 125 mmø-100 mmø-75 mmø | 0.00278853 | 134 | 378.6 | 306.3 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2090293 | yes | yes | 0.043702 | 100 | 90 | 90 | 148 | 50 | 88 | 14 | 117.5 | 125 | 191 | 177 | 90 | 100 mmø-90 mmø-90 mmø | 0.00152103 | 105 | 345 | 273 | FUSAPEX 2.0 T-Stück 125 - 125 - 125, orange | 4062178993252 | 14847261001 | https://oxomi.com/p/3000126/datasheet/-/14847261001 | 2.2
2090299 | yes | yes | 0.0647883 | 125 | 90 | 100 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 90 | 125 mmø-100 mmø-90 mmø | 0.00278853 | 134 | 386.6 | 306.3 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7
2090305 | yes | yes | 0.0647883 | 125 | 100 | 100 | 186 | 75 | 106 | 13 | 146.5 | 160 | 220.3 | 206.6 | 100 | 125 mmø-100 mmø-100 mmø | 0.00278853 | 134 | 390.6 | 306.3 | FUSAPEX 2.0 T-Stück 160 - 160 - 160, orange | 4062178993276 | 14847281001 | https://oxomi.com/p/3000126/datasheet/-/14847281001 | 4.7

# IfcFlowFitting: FUSAPEX 2.0 coupler for reducer:C 2.0 (42)
In: Level 1
Type - Material: FUSAPEX 2.0
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX 2.0 coupler for reducer; T1: FUSAPEX 2.0 coupler; T2: FUSAPEX 2.0 coupler DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: C 2.0
Type - Materials and Finishes - Mat. Coupling: FUSAPEX 2.0
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FUSAPEX 2.0 coupler for reducer:C 2.0; sets with these values: 2
Other - IsCustom: no; Type: C 2.0; Family: FUSAPEX 2.0 coupler for reducer; Family and Type: FUSAPEX 2.0 coupler for reducer: C 2.0; Type Id: 2098624
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2; HD1: 17 mm
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for FUSAPEX reducers and flange transitions Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 - automatic recognition of welding parameters using SMARTFUSE technology Kleur: - Orange Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX 2.0 coupler for reducer:C 2.0:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | HD3/2 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
2098875 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2098876 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2099117 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2099118 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2099225 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2099226 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2099297 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2099298 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2099303 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2099304 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2099400 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2099401 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2099450 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2099451 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2099456 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2099457 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2099462 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2099463 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2099587 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2099588 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2099692 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2099693 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2099698 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2099699 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2099704 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2099705 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2099710 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2099711 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2099804 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2099805 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2099895 | 110 | 158.7 | 97 | 17.65 | 13 | 4.5 | 139.6 | 91.5 | 110 mmø-110 mmø | 0.00136961 | 1.5 | FUSAPEX 2.0 Muffe 140, orange | 4062178684860 | 14847071001 | https://oxomi.com/p/3000126/datasheet/-/14847071001 | 1.295
2099896 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2100038 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2100039 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2100153 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2100154 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2100194 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2100195 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2100237 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2100238 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2100397 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2100398 | 110 | 158.7 | 97 | 17.65 | 13 | 4.5 | 139.6 | 91.5 | 110 mmø-110 mmø | 0.00136961 | 1.5 | FUSAPEX 2.0 Muffe 140, orange | 4062178684860 | 14847071001 | https://oxomi.com/p/3000126/datasheet/-/14847071001 | 1.295

# IfcFlowFitting: FUSAPEX 2.0 coupler:C 2.0 (72)
In: Level 1
Type - Material: FUSAPEX 2.0
Type - Other - Category: Pipe Fittings; Family Name: FUSAPEX 2.0 coupler; T1: FUSAPEX 2.0 coupler; T2: FUSAPEX 2.0 coupler DN1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FUSAPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: C 2.0
Type - Materials and Finishes - Mat. Coupling: FUSAPEX 2.0
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FUSAPEX 2.0 coupler:C 2.0; sets with these values: 2
Other - IsCustom: no; Family: FUSAPEX 2.0 coupler; Family and Type: FUSAPEX 2.0 coupler: C 2.0; Type: C 2.0; Type Id: 1692258
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2; HD1: 17 mm
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect - for industrial pipes RAUPEX SDR 7.4, RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for FUSAPEX reducers and flange transitions Eigenschap: - temperature resistance up to +95 °C according EN ISO 15875-5 class 5/6 bar - inner welding wire to weld - Tested according to DIN EN ISO 15875-5 - automatic recognition of welding parameters using SMARTFUSE technology Kleur: - Orange Info: - Training followed by an examination are required in order to properly work with REHAU FUSAPEX electrofusion fittings
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FUSAPEX 2.0 coupler:C 2.0:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | DoF1 (mm) | HD2 (mm) | HD2/2 (mm) | HD3 (mm) | HD3/2 (mm) | ID1 (mm) = ID2 (mm) | L1 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1692275 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15 | Graphics - Use Annotation Scale: no
1701242 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23 | Graphics - Use Annotation Scale: no
1704065 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33 | Graphics - Use Annotation Scale: no
1704117 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65 | Graphics - Use Annotation Scale: no
1704119 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832 | Graphics - Use Annotation Scale: no
1704121 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998 | Graphics - Use Annotation Scale: no
1704320 | 110 | 158.7 | 97 | 17.65 | 13 | 4.5 | 139.6 | 91.5 | 110 mmø-110 mmø | 0.00136961 | 1.5 | FUSAPEX 2.0 Muffe 140, orange | 4062178684860 | 14847071001 | https://oxomi.com/p/3000126/datasheet/-/14847071001 | 1.295 | Graphics - Use Annotation Scale: no
1704322 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752 | Graphics - Use Annotation Scale: no
1977305 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
1977390 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
1977475 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
1977604 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
1977688 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
1977805 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
1982319 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
1988443 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
1988503 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2002422 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2002495 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2002595 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2002881 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2002940 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2003420 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071004 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2071044 | 40 | 61.2 | 52 | 21.4 | 15 | 6.5 | 50 | 50 | 40 mmø-40 mmø | 0.000161546 | 1 | FUSAPEX 2.0 Muffe 50, orange | 4062178684839 | 14847011001 | https://oxomi.com/p/3000126/datasheet/-/14847011001 | 0.15
2071095 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2071097 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2071110 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2071112 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071114 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2071126 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2071128 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2071144 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090247 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090249 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090251 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090253 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090255 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090257 | 125 | 180.5 | 105 | 14.75 | 14 | 5.5 | 159.9 | 99 | 125 mmø-125 mmø | 0.001848 | 2 | FUSAPEX 2.0 Muffe 160, orange | 4062178488451 | 14847081001 | https://oxomi.com/p/3000126/datasheet/-/14847081001 | 1.752
2090261 | 50 | 73.8 | 58 | 21.1 | 17.7 | 9.2 | 63 | 59 | 50 mmø-50 mmø | 0.000237552 | 2 | FUSAPEX 2.0 Muffe 63, orange | 4062178684846 | 14847021001 | https://oxomi.com/p/3000126/datasheet/-/14847021001 | 0.23
2090267 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090273 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090279 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090285 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090291 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090297 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090303 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090309 | 100 | 143.2 | 87 | 15.4 | 12.3 | 3.8 | 125 | 86.5 | 100 mmø-100 mmø | 0.00109453 | 1.5 | FUSAPEX 2.0 Muffe 125, orange | 4062178676612 | 14847061001 | https://oxomi.com/p/3000126/datasheet/-/14847061001 | 0.998
2090311 | 65 | 87.3 | 65 | 21.35 | 18.9 | 10.4 | 75 | 63 | 65 mmø-65 mmø | 0.000343344 | 1 | FUSAPEX 2.0 Muffe 75, orange | 4062178676278 | 14847031001 | https://oxomi.com/p/3000126/datasheet/-/14847031001 | 0.33
2090315 | 75 | 106.7 | 69 | 15.65 | 16.2 | 7.7 | 90 | 74 | 75 mmø-75 mmø | 0.000592872 | 1 | FUSAPEX 2.0 Muffe 90, orange | 4062178684853 | 14847041001 | https://oxomi.com/p/3000126/datasheet/-/14847041001 | 0.65
2090317 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
2090319 | 90 | 127.7 | 79 | 15.15 | 11.6 | 3.1 | 109.9 | 81.4 | 90 mmø-90 mmø | 0.00087395 | 1.5 | FUSAPEX 2.0 Muffe 110, orange | 4062178676261 | 14847051001 | https://oxomi.com/p/3000126/datasheet/-/14847051001 | 0.832
