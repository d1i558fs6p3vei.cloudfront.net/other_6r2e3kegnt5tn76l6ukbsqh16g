Properties of the parts of a building model (IFC4), part 1 of 5

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: a98527f0-51eb-467f-bf9a-7297dd3a0e8d, VersionGUID: 264a4521-bb5f-49f8-810f-9a0b003ea442, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [BuildingService]
File name: IFC4 RV RAUPEX Gallery.ifc
Time: 2025-12-05T15:35:25+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level:Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy (8)
In: Level 1
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Lines
Pset_EnvironmentalImpactIndicators - Reference: Model Lines
Other - Category: Lines
Constraints - Moves With Nearby Elements: no; Work Plane: Level : Level 1
Graphics - Detail Line: no; Line Style: <Lines>
Phasing - Phase Created: New Construction
Name (Model Lines:...) | Length (mm)
1540933 | 13395
1540934 | 5960
1540935 | 13395
1540936 | 5960
1689382 | 14115
1689383 | 5928.42
1689384 | 14115
1689385 | 5928.42

# IfcBuildingElementProxy: Ball valve R:Ball valve R (3)
In: Level 1
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: Ball valve R; T1: Ball valve R SDR11; T2: Ball valve R SDR11 DN1+DN2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2025.01.07-419114-419114; Type Name: Ball valve R
Pset_BuildingElementProxyCommon - Reference: Ball valve R:Ball valve R; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: Ball valve R:Ball valve R
Other - IsCustom: no; Family: Ball valve R; Family and Type: Ball valve R: Ball valve R; Type: Ball valve R; Type Id: 968850
Constraints - Elevation from Level: 0 mm; Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset from Host: 0 mm
Identity Data - Sorting: 0
Phasing - Phase Created: New Construction
Name (Ball valve R:Ball valve R:...) | Area (m2) | DN1 (mm) | DN2 (mm) | HD8 (mm) | Volume (m3) | Mark
1093297 | 0.00224615 | 15 | 20 | 20 | 0.00000665546 | 1
1093409 | 0.00266689 | 20 | 25 | 21 | 0.0000098128 | 2
1093489 | 0.00281512 | 25 | 25 | 22.5 | 0.0000114492 | 3

# IfcBuildingElementProxy: Ball valve:Ball valve (6)
In: Level 1
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: Ball valve; T1: Ball valve SDR11; T2: Ball valve SDR11 DN1+DN2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.12.09-419114-419114; Type Name: Ball valve
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Ball valve:Ball valve
Pset_EnvironmentalImpactIndicators - Reference: Ball valve:Ball valve
Other - IsCustom: no; Family: Ball valve; Family and Type: Ball valve: Ball valve; Type: Ball valve; Type Id: 974140
Constraints - Elevation from Level: 0 mm; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.0047111 m2; DN1: 40 mm; DN2: 40 mm; HD8: 29 mm; Volume: 0.0000213143 m3
Identity Data - Sorting: 0
Phasing - Phase Created: New Construction
Name (Ball valve:Ball valve:...) | Mark
1098984 | 4
1099160 | 5
1099230 | 6
1099298 | 7
1099370 | 8
1099452 | 9

# IfcBuildingElementProxy: Model Text:Model Text 1 (74)
In: Level 1
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: Model Text 1
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 80 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:Model Text 1
Pset_EnvironmentalImpactIndicators - Reference: Model Text:Model Text 1
Other - Family: Model Text; Family and Type: Model Text: Model Text 1; Type: Model Text 1; Type Id: 1886
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:Model Text 1:...) | Text
1174286 | DN 15, SDR 11 20 x 1,9
1174320 | DN 20, SDR 11 25 x 2.3
1174353 | DN 25, SDR 11 32 x 2.9
1174356 | DN 32, SDR 11 40 x 3.7
1174359 | DN 40, SDR 11 50 x 4.6
1174362 | DN 50, SDR 11 63 x 5.8
1174365 | DN 65, SDR 11 75 x 6.8
1174368 | DN 75, SDR 11 90 x 8.2
1174371 | DN 90, SDR 11 110 x 10
1174374 | DN 100, SDR 11 125 x 11.4
1174424 | DN 125, SDR 11 160 x 14.6
1488279 | DN 15
1488280 | DN 20
1488281 | DN 25
1488282 | DN 32
1488283 | DN 40
1488284 | DN 50
1490281 | DN 15
1490282 | DN 20
1490283 | DN 25
1490284 | DN 32
1490285 | DN 40
1490286 | DN 50
1490287 | DN 65
1490288 | DN 75
1490289 | DN 90
1490290 | DN 100
1490291 | DN 110
1491173 | DN 125
1491701 | DN 15
1491702 | DN 20
1491703 | DN 25
1491704 | DN 32
1491705 | DN 40
1491706 | DN 50
1491707 | DN 65
1491708 | DN 75
1491709 | DN 90
1491710 | DN 100
1493085 | DN 15
1493086 | DN 20
1493087 | DN 25
1493088 | DN 32
1493089 | DN 40
1493090 | DN 50
1493091 | DN 65
1493092 | DN 75
1493093 | DN 90
1495302 | DN 15
1495303 | DN 20
1495304 | DN 25
1495305 | DN 32
1495306 | DN 40
1495307 | DN 50
1496366 | Coupling
1496383 | Elbow
1496399 | T-piece
1496416 | Adaptor
1496443 | RAUPEX A-pipe, grey
1496457 | RAUPEX K-pipe, green
1496473 | RAUTHERM FW-pipe, red
1496488 | RAUPEX O-pipe, blue
1496489 | RAUPEX UV-pipe, black
1496490 | RAUPEX M-pipe, red
1712484 | DN 40
1712485 | DN 50
1712569 | DN 65
1712579 | DN 75
1712587 | DN 90
1712595 | DN 100
1712645 | DN 110
1712659 | DN 125
1713872 | DN 25
1713873 | DN 32

# IfcBuildingElementProxy: Model Text:Model Text 2 (2)
In: Level 1
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: Model Text 2
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 160 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:Model Text 2
Pset_EnvironmentalImpactIndicators - Reference: Model Text:Model Text 2
Other - Family: Model Text; Family and Type: Model Text: Model Text 2; Type: Model Text 2; Type Id: 1540959
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:Model Text 2:...) | Text
1540954 | SDR11
1689405 | FUSAPEX

# IfcDistributionPort (958)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1085543_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 1
Port_1085543_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 1
Port_1085623_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 2
Port_1085623_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 2
Port_1085641_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 3
Port_1085641_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 3
Port_1085646_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 4
Port_1085646_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 4
Port_1085651_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 5
Port_1085651_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 5
Port_1085656_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 6
Port_1085656_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 6
Port_1085661_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 7
Port_1085661_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 7
Port_1085666_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 8
Port_1085666_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 8
Port_1085671_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_1085671_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_1085676_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 10
Port_1085676_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 10
Port_1085681_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 11
Port_1085681_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 11
Port_1086086_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 12
Port_1086086_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 12
Port_1086088_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 13
Port_1086088_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 13
Port_1086090_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 14
Port_1086090_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 14
Port_1086092_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 15
Port_1086092_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 15
Port_1086094_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 16
Port_1086094_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 16
Port_1086096_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 17
Port_1086096_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 17
Port_1086098_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 18
Port_1086098_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 18
Port_1086100_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 19
Port_1086100_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 19
Port_1086102_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 20
Port_1086102_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 20
Port_1086104_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 21
Port_1086104_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 21
Port_1086106_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 22
Port_1086106_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 22
Port_1086136_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 23
Port_1086136_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 23
Port_1086138_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 24
Port_1086138_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 24
Port_1086140_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 25
Port_1086140_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 25
Port_1086142_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 26
Port_1086142_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 26
Port_1086144_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 27
Port_1086144_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 27
Port_1086146_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 28
Port_1086146_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 28
Port_1086148_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 29
Port_1086148_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 29
Port_1086150_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 30
Port_1086150_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 30
Port_1086152_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 31
Port_1086152_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 31
Port_1086154_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 32
Port_1086154_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 32
Port_1086156_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 33
Port_1086156_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 33
Port_1086171_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 34
Port_1086171_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 34
Port_1086173_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 35
Port_1086173_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 35
Port_1086175_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 36
Port_1086175_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 36
Port_1086177_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 37
Port_1086177_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 37
Port_1086179_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 38
Port_1086179_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 38
Port_1086181_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 39
Port_1086181_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 39
Port_1086183_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 40
Port_1086183_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 40
Port_1086185_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 41
Port_1086185_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 41
Port_1086187_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 42
Port_1086187_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 42
Port_1086189_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 43
Port_1086189_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 43
Port_1086191_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 44
Port_1086191_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 44
Port_1086206_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 45
Port_1086206_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 45
Port_1086208_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 46
Port_1086208_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 46
Port_1086210_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 47
Port_1086210_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 47
Port_1086212_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 48
Port_1086212_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 48
Port_1086214_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 49
Port_1086214_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 49
Port_1086216_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 50
Port_1086216_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 50
Port_1086218_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 51
Port_1086218_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 51
Port_1086220_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 52
Port_1086220_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 52
Port_1086222_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_1086222_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_1086224_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 54
Port_1086224_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 54
Port_1086226_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 55
Port_1086226_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 55
Port_1086289_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 57
Port_1086289_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 57
Port_1086291_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 58
Port_1086291_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 58
Port_1086293_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 59
Port_1086293_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 59
Port_1086295_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 60
Port_1086295_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 60
Port_1086297_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 61
Port_1086297_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 61
Port_1086299_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 62
Port_1086299_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 62
Port_1086301_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 63
Port_1086301_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 63
Port_1086303_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 64
Port_1086303_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 64
Port_1086305_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 65
Port_1086305_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 65
Port_1086307_0 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 66
Port_1086307_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 66
Port_1086953_2
Port_1086953_3
Port_1088177_2
Port_1088177_3
Port_1088300_2
Port_1088300_3
Port_1088304_2
Port_1088304_3
Port_1092397_3
Port_1092397_4
Port_1092403_3
Port_1092403_4
Port_1092409_3
Port_1092409_4
Port_1092415_3
Port_1092415_4
Port_1092421_3
Port_1092421_4
Port_1092427_3
Port_1092427_4
Port_1092433_3
Port_1092433_4
Port_1092439_3
Port_1092439_4
Port_1093294_1
Port_1093294_2
Port_1093406_1
Port_1093406_2
Port_1093486_1
Port_1093486_2
Port_1098981_1
Port_1098981_2
Port_1099157_1
Port_1099157_2
Port_1099227_1
Port_1099227_2
Port_1099295_1
Port_1099295_2
Port_1099367_1
Port_1099367_2
Port_1099449_1
Port_1099449_2
Port_1119054_1
Port_1119054_2
Port_1119084_1
Port_1119084_2
Port_1119092_1
Port_1119092_2
Port_1119100_1
Port_1119100_2
Port_1119108_1
Port_1119108_2
Port_1119116_1
Port_1119116_2
Port_1119124_1
Port_1119124_2
Port_1119132_1
Port_1119132_2
Port_1119140_1
Port_1119140_2
Port_1119148_1
Port_1119148_2
Port_1119164_1
Port_1119164_2
Port_1134568_2
Port_1134568_3
Port_1134574_2
Port_1134574_3
Port_1134580_2
Port_1134580_3
Port_1134586_2
Port_1134586_3
Port_1134871_2
Port_1134871_3
Port_1142760_1
Port_1142760_2
Port_1142907_1
Port_1142907_2
Port_1143591_1
Port_1143591_2
Port_1143599_1
Port_1143599_2
Port_1143607_1
Port_1143607_2
Port_1143615_1
Port_1143615_2
Port_1143623_1
Port_1143623_2
Port_1143631_1
Port_1143631_2
Port_1153946_3
Port_1153946_4
Port_1153962_3
Port_1153962_4
Port_1153968_3
Port_1153968_4
Port_1153974_3
Port_1153974_4
Port_1153980_3
Port_1153980_4
Port_1153986_3
Port_1153986_4
Port_1153992_3
Port_1153992_4
Port_1154169_2
Port_1154169_3
Port_1154175_2
Port_1154175_3
Port_1154181_2
Port_1154181_3
Port_1154187_2
Port_1154187_3
Port_1154193_2
Port_1154193_3
Port_1154199_2
Port_1154199_3
Port_1154205_2
Port_1154205_3
Port_1154211_2
Port_1154211_3
Port_1154217_2
Port_1154217_3
Port_1154223_2
Port_1154223_3
Port_1154229_2
Port_1154229_3
Port_1154235_2
Port_1154235_3
Port_1154241_2
Port_1154241_3
Port_1160547_3
Port_1160547_4
Port_1160547_5
Port_1160565_3
Port_1160565_4
Port_1160565_5
Port_1160573_3
Port_1160573_4
Port_1160573_5
Port_1160581_3
Port_1160581_4
Port_1160581_5
Port_1160589_3
Port_1160589_4
Port_1160589_5
Port_1160597_3
Port_1160597_4
Port_1160597_5
Port_1160605_3
Port_1160605_4
Port_1160605_5
Port_1160613_3
Port_1160613_4
Port_1160613_5
Port_1160621_3
Port_1160621_4
Port_1160621_5
Port_1160629_3
Port_1160629_4
Port_1160629_5
Port_1160637_3
Port_1160637_4
Port_1160637_5
Port_1160645_3
Port_1160645_4
Port_1160645_5
Port_1160653_3
Port_1160653_4
Port_1160653_5
Port_1160661_3
Port_1160661_4
Port_1160661_5
Port_1160669_3
Port_1160669_4
Port_1160669_5
Port_1173556_1
Port_1173556_2
Port_1173562_1
Port_1173562_2
Port_1173592_1
Port_1173592_2
Port_1173711_1
Port_1173711_2
Port_1173717_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 56
Port_1173717_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 56
Port_1173723_1
Port_1173723_2
Port_1173729_1
Port_1173729_2
Port_1173735_1
Port_1173735_2
Port_1173920_1
Port_1173920_2
Port_1197117_3
Port_1197117_4
Port_1197117_5
Port_1197130_3
Port_1197130_4
Port_1197130_5
Port_1201061_1
Port_1201061_2
Port_1201061_3
Port_1201304_1
Port_1201304_2
Port_1201304_3
Port_1201454_1
Port_1201454_2
Port_1201454_3
Port_1201548_1
Port_1201548_2
Port_1201548_3
Port_1204903_1
Port_1204903_2
Port_1204903_3
Port_1207304_1
Port_1207304_2
Port_1207304_3
Port_1207312_1
Port_1207312_2
Port_1207312_3
Port_1210783_1
Port_1210783_2
Port_1210783_3
Port_1210914_1
Port_1210914_2
Port_1210914_3
Port_1211083_1
Port_1211083_2
Port_1211083_3
Port_1211091_1
Port_1211091_2
Port_1211091_3
Port_1211099_1
Port_1211099_2
Port_1211099_3
Port_1211107_1
Port_1211107_2
Port_1211107_3
Port_1211115_1
Port_1211115_2
Port_1211115_3
Port_1211123_1
Port_1211123_2
Port_1211123_3
Port_1211346_1
Port_1211346_2
Port_1211346_3
Port_1211536_1
Port_1211536_2
Port_1211536_3
Port_1211627_1
Port_1211627_2
Port_1211627_3
Port_1211635_1
Port_1211635_2
Port_1211635_3
Port_1212061_1
Port_1212061_2
Port_1212061_3
Port_1212364_1
Port_1212364_2
Port_1212364_3
Port_1212372_1
Port_1212372_2
Port_1212372_3
Port_1212380_1
Port_1212380_2
Port_1212380_3
Port_1212388_1
Port_1212388_2
Port_1212388_3
Port_1212396_1
Port_1212396_2
Port_1212396_3
Port_1212404_1
Port_1212404_2
Port_1212404_3
Port_1212412_1
Port_1212412_2
Port_1212412_3
Port_1212420_1
Port_1212420_2
Port_1212420_3
Port_1212428_1
Port_1212428_2
Port_1212428_3
Port_1212790_1
Port_1212790_2
Port_1212790_3
Port_1212798_1
Port_1212798_2
Port_1212798_3
Port_1212914_1
Port_1212914_2
Port_1212914_3
Port_1212992_1
Port_1212992_2
Port_1212992_3
Port_1213088_1
Port_1213088_2
Port_1213088_3
Port_1213222_1
Port_1213222_2
Port_1213222_3
Port_1213321_1
Port_1213321_2
Port_1213321_3
Port_1213439_1
Port_1213439_2
Port_1213439_3
Port_1213568_1
Port_1213568_2
Port_1213568_3
Port_1213596_1
Port_1213596_2
Port_1213596_3
Port_1213606_1
Port_1213606_2
Port_1213606_3
Port_1213616_1
Port_1213616_2
Port_1213616_3
Port_1213626_1
Port_1213626_2
Port_1213626_3
Port_1213636_1
Port_1213636_2
Port_1213636_3
Port_1213646_1
Port_1213646_2
Port_1213646_3
Port_1213750_1
Port_1213750_2
Port_1213750_3
Port_1213780_1
Port_1213780_2
Port_1213780_3
Port_1213788_1
Port_1213788_2
Port_1213788_3
Port_1213796_1
Port_1213796_2
Port_1213796_3
Port_1213804_1
Port_1213804_2
Port_1213804_3
Port_1279232_1
Port_1279232_2
Port_1279384_1
Port_1279384_2
Port_1281987_1
Port_1281987_2
Port_1281993_1
Port_1281993_2
Port_1284701_1
Port_1284701_2
Port_1284707_1
Port_1284707_2
Port_1284713_1
Port_1284713_2
Port_1284719_1
Port_1284719_2
Port_1285144_1
Port_1285144_2
Port_1285157_1
Port_1285157_2
Port_1327808_1
Port_1327808_2
Port_1327808_3
Port_1357839_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 72
Port_1357839_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 72
Port_1357857_1
Port_1357857_2
Port_1357863_1
Port_1357863_2
Port_1357869_1
Port_1357869_2
Port_1357875_1
Port_1357875_2
Port_1395633_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 67
Port_1395633_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 67
Port_1405583_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 70
Port_1405583_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 70
Port_1405635_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 69
Port_1405635_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 69
Port_1405757_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 68
Port_1405757_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 68
Port_1423079_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 71
Port_1423079_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 71
Port_1423528_1 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 73
Port_1423528_2 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 73
Port_1491241_1
Port_1491241_2
Port_1560502_4 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 74
Port_1560502_5 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 74
Port_1560502_6 | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 74
Port_1597063_4
Port_1597063_5
Port_1597063_6
Port_1688801_1
Port_1688801_2
Port_1688801_3
Port_1692275_1
Port_1692275_2
Port_1693803_1
Port_1693803_2
Port_1695245_1
Port_1695245_2
Port_1696747_1
Port_1696747_2
Port_1698229_1
Port_1698229_2
Port_1701242_1
Port_1701242_2
Port_1704065_1
Port_1704065_2
Port_1704117_1
Port_1704117_2
Port_1704119_1
Port_1704119_2
Port_1704121_1
Port_1704121_2
Port_1704320_1
Port_1704320_2
Port_1704322_1
Port_1704322_2
Port_1706680_1
Port_1706680_2
Port_1706723_1
Port_1706723_2
Port_1707071_1
Port_1707071_2
Port_1707080_1
Port_1707080_2
Port_1707089_1
Port_1707089_2
Port_1707100_1
Port_1707100_2
Port_1707109_1
Port_1707109_2
Port_1707118_1
Port_1707118_2
Port_1707389_1
Port_1707389_2
Port_1711162_1
Port_1711162_2
Port_1711250_1
Port_1711250_2
Port_1969888_1
Port_1969888_2
Port_1969888_3
Port_1976804_1
Port_1976804_2
Port_1976804_3
Port_1977213_1
Port_1977213_2
Port_1977213_3
Port_1977229_1
Port_1977229_2
Port_1977229_3
Port_1977235_1
Port_1977235_2
Port_1977235_3
Port_1977241_1
Port_1977241_2
Port_1977241_3
Port_1977247_1
Port_1977247_2
Port_1977247_3
Port_1977259_1
Port_1977259_2
Port_1977259_3
Port_1977305_1
Port_1977305_2
Port_1977390_1
Port_1977390_2
Port_1977475_1
Port_1977475_2
Port_1977604_1
Port_1977604_2
Port_1977688_1
Port_1977688_2
Port_1977805_1
Port_1977805_2
Port_1982315_1
Port_1982319_1
Port_1982319_2
Port_1988097_1
Port_1988097_2
Port_1988097_3
Port_1988439_1
Port_1988443_1
Port_1988443_2
Port_1988497_1
Port_1988497_2
Port_1988497_3
Port_1988499_1
Port_1988503_1
Port_1988503_2
Port_2002328_1
Port_2002328_2
Port_2002328_3
Port_2002418_1
Port_2002422_1
Port_2002422_2
Port_2002489_1
Port_2002489_2
Port_2002489_3
Port_2002491_1
Port_2002495_1
Port_2002495_2
Port_2002589_1
Port_2002589_2
Port_2002589_3
Port_2002591_1
Port_2002595_1
Port_2002595_2
Port_2002813_1
Port_2002813_2
Port_2002813_3
Port_2002877_1
Port_2002881_1
Port_2002881_2
Port_2002934_1
Port_2002934_2
Port_2002934_3
Port_2002936_1
Port_2002940_1
Port_2002940_2
Port_2003131_1
Port_2003131_2
Port_2003131_3
Port_2003416_1
Port_2003420_1
Port_2003420_2
Port_2071004_1
Port_2071004_2
Port_2071044_1
Port_2071044_2
Port_2071095_1
Port_2071095_2
Port_2071097_1
Port_2071097_2
Port_2071110_1
Port_2071110_2
Port_2071112_1
Port_2071112_2
Port_2071114_1
Port_2071114_2
Port_2071126_1
Port_2071126_2
Port_2071128_1
Port_2071128_2
Port_2071144_1
Port_2071144_2
Port_2090231_1
Port_2090231_2
Port_2090231_3
Port_2090235_1
Port_2090235_2
Port_2090235_3
Port_2090237_1
Port_2090237_2
Port_2090237_3
Port_2090239_1
Port_2090239_2
Port_2090239_3
Port_2090241_1
Port_2090241_2
Port_2090241_3
Port_2090243_1
Port_2090243_2
Port_2090243_3
Port_2090245_1
Port_2090245_2
Port_2090245_3
Port_2090247_1
Port_2090247_2
Port_2090249_1
Port_2090249_2
Port_2090251_1
Port_2090251_2
Port_2090253_1
Port_2090253_2
Port_2090255_1
Port_2090255_2
Port_2090257_1
Port_2090257_2
Port_2090259_1
Port_2090261_1
Port_2090261_2
Port_2090263_1
Port_2090263_2
Port_2090263_3
Port_2090265_1
Port_2090267_1
Port_2090267_2
Port_2090269_1
Port_2090269_2
Port_2090269_3
Port_2090271_1
Port_2090273_1
Port_2090273_2
Port_2090275_1
Port_2090275_2
Port_2090275_3
Port_2090277_1
Port_2090279_1
Port_2090279_2
Port_2090281_1
Port_2090281_2
Port_2090281_3
Port_2090283_1
Port_2090285_1
Port_2090285_2
Port_2090287_1
Port_2090287_2
Port_2090287_3
Port_2090289_1
Port_2090291_1
Port_2090291_2
Port_2090293_1
Port_2090293_2
Port_2090293_3
Port_2090295_1
Port_2090297_1
Port_2090297_2
Port_2090299_1
Port_2090299_2
Port_2090299_3
Port_2090301_1
Port_2090303_1
Port_2090303_2
Port_2090305_1
Port_2090305_2
Port_2090305_3
Port_2090307_1
Port_2090309_1
Port_2090309_2
Port_2090311_1
Port_2090311_2
Port_2090315_1
Port_2090315_2
Port_2090317_1
Port_2090317_2
Port_2090319_1
Port_2090319_2
Port_2090321_1
Port_2090321_2
Port_2090323_1
Port_2090323_2
Port_2090325_1
Port_2090325_2
Port_2090327_1
Port_2090327_2
Port_2090329_1
Port_2090329_2
Port_2090385_1
Port_2090387_1
Port_2090387_2
Port_2090430_1
Port_2090432_1
Port_2090432_2
Port_2090472_1
Port_2090480_1
Port_2090480_2
Port_2090558_1
Port_2090560_1
Port_2090560_2
Port_2090616_1
Port_2090618_1
Port_2090618_2
Port_2090680_1
Port_2090682_1
Port_2090682_2
Port_2090726_1
Port_2090734_1
Port_2090734_2
Port_2090810_1
Port_2090812_1
Port_2090812_2
Port_2090856_1
Port_2090864_1
Port_2090864_2
Port_2090986_1
Port_2090988_1
Port_2090988_2
Port_2091032_1
Port_2091040_1
Port_2091040_2
Port_2091105_1
Port_2091107_1
Port_2091107_2
Port_2091149_1
Port_2091151_1
Port_2091151_2
Port_2091191_1
Port_2091193_1
Port_2091193_2
Port_2091247_1
Port_2091249_1
Port_2091249_2
Port_2098874_1
Port_2098874_2
Port_2098875_1
Port_2098875_2
Port_2098876_1
Port_2098876_2
Port_2099116_1
Port_2099116_2
Port_2099117_1
Port_2099117_2
Port_2099118_1
Port_2099118_2
Port_2099224_1
Port_2099224_2
Port_2099225_1
Port_2099225_2
Port_2099226_1
Port_2099226_2
Port_2099296_1
Port_2099296_2
Port_2099297_1
Port_2099297_2
Port_2099298_1
Port_2099298_2
Port_2099302_1
Port_2099302_2
Port_2099303_1
Port_2099303_2
Port_2099304_1
Port_2099304_2
Port_2099399_1
Port_2099399_2
Port_2099400_1
Port_2099400_2
Port_2099401_1
Port_2099401_2
Port_2099449_1
Port_2099449_2
Port_2099450_1
Port_2099450_2
Port_2099451_1
Port_2099451_2
Port_2099455_1
Port_2099455_2
Port_2099456_1
Port_2099456_2
Port_2099457_1
Port_2099457_2
Port_2099461_1
Port_2099461_2
Port_2099462_1
Port_2099462_2
Port_2099463_1
Port_2099463_2
Port_2099586_1
Port_2099586_2
Port_2099587_1
Port_2099587_2
Port_2099588_1
Port_2099588_2
Port_2099691_1
Port_2099691_2
Port_2099692_1
Port_2099692_2
Port_2099693_1
Port_2099693_2
Port_2099697_1
Port_2099697_2
Port_2099698_1
Port_2099698_2
Port_2099699_1
Port_2099699_2
Port_2099703_1
Port_2099703_2
Port_2099704_1
Port_2099704_2
Port_2099705_1
Port_2099705_2
Port_2099709_1
Port_2099709_2
Port_2099710_1
Port_2099710_2
Port_2099711_1
Port_2099711_2
Port_2099803_1
Port_2099803_2
Port_2099804_1
Port_2099804_2
Port_2099805_1
Port_2099805_2
Port_2099894_1
Port_2099894_2
Port_2099895_1
Port_2099895_2
Port_2099896_1
Port_2099896_2
Port_2100037_1
Port_2100037_2
Port_2100038_1
Port_2100038_2
Port_2100039_1
Port_2100039_2
Port_2100152_1
Port_2100152_2
Port_2100153_1
Port_2100153_2
Port_2100154_1
Port_2100154_2
Port_2100193_1
Port_2100193_2
Port_2100194_1
Port_2100194_2
Port_2100195_1
Port_2100195_2
Port_2100236_1
Port_2100236_2
Port_2100237_1
Port_2100237_2
Port_2100238_1
Port_2100238_2
Port_2100396_1
Port_2100396_2
Port_2100397_1
Port_2100397_2
Port_2100398_1
Port_2100398_2

# IfcDistributionSystem: Domestic Cold Water (74)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Piping System:Domestic Cold Water
Name
Domestic Cold Water 1
Domestic Cold Water 2
Domestic Cold Water 3
Domestic Cold Water 4
Domestic Cold Water 5
Domestic Cold Water 6
Domestic Cold Water 7
Domestic Cold Water 8
Domestic Cold Water 9
Domestic Cold Water 10
Domestic Cold Water 11
Domestic Cold Water 12
Domestic Cold Water 13
Domestic Cold Water 14
Domestic Cold Water 15
Domestic Cold Water 16
Domestic Cold Water 17
Domestic Cold Water 18
Domestic Cold Water 19
Domestic Cold Water 20
Domestic Cold Water 21
Domestic Cold Water 22
Domestic Cold Water 23
Domestic Cold Water 24
Domestic Cold Water 25
Domestic Cold Water 26
Domestic Cold Water 27
Domestic Cold Water 28
Domestic Cold Water 29
Domestic Cold Water 30
Domestic Cold Water 31
Domestic Cold Water 32
Domestic Cold Water 33
Domestic Cold Water 34
Domestic Cold Water 35
Domestic Cold Water 36
Domestic Cold Water 37
Domestic Cold Water 38
Domestic Cold Water 39
Domestic Cold Water 40
Domestic Cold Water 41
Domestic Cold Water 42
Domestic Cold Water 43
Domestic Cold Water 44
Domestic Cold Water 45
Domestic Cold Water 46
Domestic Cold Water 47
Domestic Cold Water 48
Domestic Cold Water 49
Domestic Cold Water 50
Domestic Cold Water 51
Domestic Cold Water 52
Domestic Cold Water 53
Domestic Cold Water 54
Domestic Cold Water 55
Domestic Cold Water 57
Domestic Cold Water 58
Domestic Cold Water 59
Domestic Cold Water 60
Domestic Cold Water 61
Domestic Cold Water 62
Domestic Cold Water 63
Domestic Cold Water 64
Domestic Cold Water 65
Domestic Cold Water 66
Domestic Cold Water 56
Domestic Cold Water 72
Domestic Cold Water 67
Domestic Cold Water 70
Domestic Cold Water 69
Domestic Cold Water 68
Domestic Cold Water 71
Domestic Cold Water 73
Domestic Cold Water 74

# IfcPipeFitting: Adapter taper SDR11 LX 24 Grad:Adapter taper SDR11 24 LX (2)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Adapter taper SDR11 LX 24 Grad; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Adapter taper SDR11 24 Grad LX; T2: Adapter taper SDR11 24 Grad LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Adapter taper SDR11 24 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Adapter taper SDR11 LX 24 Grad:Adapter taper SDR11 24 LX; sets with these values: 2
Other - Family: Adapter taper SDR11 LX 24 Grad; Family and Type: Adapter taper SDR11 LX 24 Grad: Adapter taper SDR11 24 LX; IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Type: Adapter taper SDR11 24 LX; Type Id: 1061313
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; DN1: 25 mm; ID1: 22.4 mm; Maximum Size: 25 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025; Sorting: 0; Tender text: Toepassing: - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL Eigenschap: - Outlet designed as external thread with internal cone 24° according to ISO 8434-1 to connect a hose fitting with sealing head and union nut light series (L) in a metallically sealing way. Materiaal: - Brass Kleur: - brass Info: - Suitable for Push-Lok fittings series 82 DKL (C3, C4, C5)
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Adapter taper SDR11 LX 24 Grad:Adapter taper SDR11 24 LX:...) | A (deg) | DN2 (mm) = Minimum Size (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1086953 | 60 | 20 | 15 | 25 mmø-20 mmø | 22 | 11 | 0.0000184861 | 8.7 | 14 | REHAU Übergang Konus, SDR 11 LX 32 x 2,9 - M22 x 1,5, 24 Grad | 4064299691291 | 11693001001 | https://oxomi.com/p/3000126/datasheet/-/11693001001 | 0.13
1088177 | 45 | 25 | 22 | 25 mmø-25 mmø | 30 | 15 | 0.00002379 | 8.9 | 6 | REHAU Übergang Konus, SDR 11 LX 32 x 2,9 - M30 x 2, 24 Grad | 4064299722605 | 11693011001 | https://oxomi.com/p/3000126/datasheet/-/11693011001 | 0.148

# IfcPipeFitting: Adapter taper SDR11 LX 60 Grad:Adapter taper SDR11 60 LX (2)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Adapter taper SDR11 LX 60 Grad; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Adapter taper SDR11 60 Grad LX; T2: Adapter taper SDR11 60 Grad LX DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: Adapter taper SDR11 60 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Adapter taper SDR11 LX 60 Grad:Adapter taper SDR11 60 LX; sets with these values: 2
Other - A: 60 deg; IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Adapter taper SDR11 LX 60 Grad; Family and Type: Adapter taper SDR11 LX 60 Grad: Adapter taper SDR11 60 LX; Type: Adapter taper SDR11 60 LX; Type Id: 1064243
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; DN1: 25 mm; ID1: 22.4 mm; Maximum Size: 25 mm; SWL: 27 mm; SWL/2: 13.5 mm; Z1: 8.9 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO Probe PE-Xa green, RAUGEO collect, RAUGEO collect plus, RAUGEO Helix XXL Eigenschap: - outlet with external thread with 60° conus Materiaal: - Brass Kleur: - brass
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Adapter taper SDR11 LX 60 Grad:Adapter taper SDR11 60 LX:...) | DN2 (mm) = Minimum Size (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1088300 | 20 | 18 | 25 mmø-20 mmø | 0.0000197841 | 9.1 | REHAU Übergang Konus, SDR 11 LX 32 - G 3/4, 60 Grad | 4059757288229 | 13213461001 | https://oxomi.com/p/3000126/datasheet/-/13213461001 | 0.13
1088304 | 15 | 13 | 25 mmø-15 mmø | 0.0000175997 | 8.1 | REHAU Übergang Konus, SDR 11 LX 32 - G 1/2, 60 Grad | 4007360484316 | 11691681001 | https://oxomi.com/p/3000126/datasheet/-/11691681001 | 0.099

# IfcPipeFitting: Adapter with union nut SDR11:A union nut LX (8)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Adapter with union nut SDR11; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Straight union connector SDR11; T2: Straight union connector SDR11 DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: Industrierohrsysteme; REHAU Info: 2025.03.27-419114-419114; Type Name: A union nut LX; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Adapter with union nut SDR11:A union nut LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Adapter with union nut SDR11; Family and Type: Adapter with union nut SDR11: A union nut LX; Type: A union nut LX; Type Id: 1091908
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Adapter with union nut SDR11:A union nut LX:...) | V1 | V2 | Angle (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | IDoutside (mm) | L2 (mm) | LG (mm) | L SLW (mm) | L SLW/2 (mm) | Size = Overall Size | SLW (mm) | SLW*2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
1092397 | no | yes | 60 | 15 | 15 | 13.6 | 11 | 18.5 | 10.4 | 17.5 | 6.5 | 3.25 | 15 mmø-15 mmø | 13 | 26 | 0.00000801563 | 17.6 | 6.3 | REHAU Übergang m. Überwurfm. SDR 11 LX 20 - G 1/2 | 4007360456894 | 11690951001 | 0.06
1092403 | no | yes | 60 | 15 | 20 | 13.6 | 13.6 | 24 | 11 | 20.3 | 9.5 | 4.75 | 20 mmø-15 mmø | 15 | 30 | 0.0000129183 | 14 | 8.5 | REHAU Übergang m. Überwurfm. SDR 11 LX 20 - G 3/4 | 4007360456900 | 11690961001 | 0.07
1092409 | no | yes | 60 | 20 | 20 | 17.8 | 16 | 24 | 8.2 | 20.5 | 9.5 | 4.75 | 20 mmø-20 mmø | 15 | 30 | 0.000012355 | 14.8 | 5.7 | REHAU Übergang m. Überwurfm. SDR 11 LX 25 - G 3/4 | 4007360456986 | 11691031001 | 0.085
1092415 | no | yes | 60 | 20 | 25 | 17.8 | 17.8 | 30.6 | 10.3 | 23 | 11.5 | 5.75 | 25 mmø-20 mmø | 19 | 38 | 0.0000204897 | 15.7 | 7.8 | REHAU Übergang m. Überwurfm. SDR 11 LX 25 - G 1 | 4007360456962 | 11691021001 | 0.095
1092421 | no | yes | 60 | 25 | 25 | 22.4 | 20 | 30.6 | 11 | 24 | 11.5 | 5.75 | 25 mmø-25 mmø | 19 | 38 | 0.0000246271 | 16 | 8 | REHAU Übergang m. Überwurfm. SDR 11 LX 32 - G 1 | 4007360549039 | 11691941001 | 0.11
1092427 | no | yes | 60 | 32 | 32 | 26 | 26 | 36 | 9.2 | 24 | 11.5 | 5.75 | 32 mmø-32 mmø | 19 | 38 | 0.0000411452 | 17.8 | 6.2 | REHAU Übergang m. Überwurfm. SDR 11 LX 40 - G 1 1/4 | 4007360549053 | 11692141001 | 0.15
1092433 | yes | no | 45 | 40 | 40 | 35.5 | 28 | 44 | 12.7 | 23.6 | 16 | 8 | 40 mmø-40 mmø | 26 | 52 | 0.0000619451 | 17 | 8.2 | REHAU Übergang mit Überwurfmutter SDR 11 50 x 4,6 - G 1 1/2 | 4064299605816 | 11092191001 | 0.467
1092439 | yes | no | 45 | 50 | 50 | 45.5 | 30 | 56 | 16.3 | 28.8 | 15 | 7.5 | 50 mmø-50 mmø | 32.5 | 65 | 0.000100949 | 23 | 9.3 | REHAU Übergang mit Überwurfmutter SDR 11 63 x 5,8 - G 2 | 4064299605823 | 11092211001 | 0.838

# IfcPipeFitting: Adapter with welding end:A welding LX (5)
In: Level 1
Type - Material: REHAU_steel
Type - Other - Category: Pipe Fittings; Family Name: Adapter with welding end; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Adapter with welding end SDR11; T2: Adapter with welding end SDR11 DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: A welding LX; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - Mat. Coupling: REHAU_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Adapter with welding end:A welding LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; Family: Adapter with welding end; Family and Type: Adapter with welding end: A welding LX; Type: A welding LX; Type Id: 1360505
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for welding with a corresponding steel pipe Materiaal: - steel P355N Info: - Not suitable for use with drinking water !
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Adapter with welding end:A welding LX:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight | System Name = Group
1357839 | 50 | 44 | 54.5 | 50 mmø-50 mmø | 0.0000831023 | 17.5 | 7.4 | REHAU Übergang mit Schweißende, SDR 11 63 x 5,8 - 60,3 x 2,9 | 4007360213770 | 12672411001 | https://oxomi.com/p/3000126/datasheet/-/12672411001 | 0.55 | Domestic Cold Water 72
1395633 | 20 | 18 | 22 | 20 mmø-20 mmø | 0.00000928544 | 12.5 | 10 | REHAU Übergang mit Schweißende, SDR 11 25 x 2,3 - 26 x 2,9 | 4007360213749 | 12671611001 | https://oxomi.com/p/3000126/datasheet/-/12671611001 | 0.07 | Domestic Cold Water 67
1405583 | 40 | 34 | 43.1 | 40 mmø-40 mmø | 0.0000561702 | 14.8 | 5.9 | REHAU Übergang mit Schweißende, SDR 11 50 x 4,6 - 48,3 x 2,6 | 4007360213763 | 12672211001 | https://oxomi.com/p/3000126/datasheet/-/12672211001 | 0.41 | Domestic Cold Water 70
1405635 | 32 | 26.9 | 37.2 | 32 mmø-32 mmø | 0.00003435 | 15.3 | 4 | REHAU Übergang mit Schweißende, SDR 11 40 x 3,7 - 42,4 x 2,6 | 4007360213756 | 12672011001 | https://oxomi.com/p/3000126/datasheet/-/12672011001 | 0.27 | Domestic Cold Water 69
1405757 | 25 | 22 | 28 | 25 mmø-25 mmø | 0.0000180053 | 13.2 | 4 | REHAU Übergang mit Schweißende, SDR 11 32 x 2,9 - 33,7 x 2,6 | 4007360149482 | 12671811001 | https://oxomi.com/p/3000126/datasheet/-/12671811001 | 0.13 | Domestic Cold Water 68

# IfcPipeFitting: Adapter with welding end:A welding RX (6)
In: Level 1
Type - Material: REHAU_steel
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; Family Name: Adapter with welding end; Max sleeve: 50 mm; T1: Adapter with welding end SDR11; T2: Adapter with welding end SDR11 DN1+2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: RX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: A welding RX; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - Mat. Coupling: REHAU_steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Adapter with welding end:A welding RX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : RX 11; Sleeve DN2: Sleeve : RX 11; Family: Adapter with welding end; Family and Type: Adapter with welding end: A welding RX; Type: A welding RX; Type Id: 1360507
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 - for welding with a corresponding steel pipe Materiaal: - steel P355N Info: - Not suitable for use with drinking water !
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Adapter with welding end:A welding RX:...) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight | System Classification
1357857 | 90 | 100 | 82 | 106 | 100 mmø-90 mmø | 0.000250071 | 15.2 | 6 | REHAU Übergang mit Schweißende, SDR 11 110 x 10 - 114,3 x 3,6 | 4007360221478 | 12673011001 | https://oxomi.com/p/3000126/datasheet/-/12673011001 | 1.55 | Undefined
1357863 | 100 | 125 | 90 | 134 | 125 mmø-100 mmø | 0.00031264 | 16.7 | 5 | REHAU Übergang mit Schweißende, SDR 11 125 x 11,4 - 139,6 x 3,6 | 4007360218300 | 12352091001 | https://oxomi.com/p/3000126/datasheet/-/12352091001 | 2.8 | Undefined
1357869 | 110 | 125 | 101 | 132 | 125 mmø-110 mmø | 0.000414069 | 22 | 14 | REHAU Übergang mit Schweißende, SDR 11 140 x 12,7 - 139,7 x 3,6 | 4007360469665 | 12062531001 | https://oxomi.com/p/3000126/datasheet/-/12062531001 | 4 | Undefined
1357875 | 125 | 150 | 116 | 160 | 150 mmø-125 mmø | 0.000540017 | 22 | 16 | REHAU Übergang mit Schweißende, SDR 11 160 x 14,6 - 168,3 x 4,1 | 4007360218249 | 12316261001 | https://oxomi.com/p/3000126/datasheet/-/12316261001 | 4.92 | Undefined
1423079 | 65 | 65 | 52 | 70 | 65 mmø-65 mmø | 0.000129594 | 16 | 7 | REHAU Übergang mit Schweißende, SDR 11 75 x 6,8 - 76,1 x 2,9 | 4007360213787 | 12672611001 | https://oxomi.com/p/3000126/datasheet/-/12672611001 | 0.84 | Domestic Cold Water | Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 71; Group: Domestic Cold Water 71
1423528 | 75 | 75 | 70 | 84 | 75 mmø-75 mmø | 0.000139354 | 14.8 | 10 | REHAU Übergang mit Schweißende, SDR 11 90 x 8,2 - 88,9 x 3,2 | 4007360213794 | 12672811001 | https://oxomi.com/p/3000126/datasheet/-/12672811001 | 1.11 | Domestic Cold Water | Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 73; Group: Domestic Cold Water 73

# IfcPipeFitting: Ball valve R SDR11:BV R SDR11 LX (3)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Ball valve R SDR11; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Ball valve R SDR11; T2: Ball valve R SDR11 DN1+DN2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: BV R SDR11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Ball valve R SDR11:BV R SDR11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; A: 45 deg; V2: no; Family: Ball valve R SDR11; Family and Type: Ball valve R SDR11: BV R SDR11 LX; Type: BV R SDR11 LX; Type 0: yes; Type 1: no; Type Id: 1069505
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect, RAUGEO collect plus - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Body: dezincification resistant special brass according to EN 12164 to EN 12168 - sealing: PTFE - ball: chrome-plated brass - hand lever: galvanised steel, plastic coated
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Ball valve R SDR11:BV R SDR11 LX:...) | V1 | C (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | HD2 (mm) | HD2/2 (mm) | HD4 (mm) | HD5 (mm) | ID1 (mm) | ID2 (mm) | LC (mm) | Size = Overall Size | SLW (mm) | SLW/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1093294 | no | 5.5 | 15 | 20 | 7.2 | 3.6 | 7 | 27.5 | 13.6 | 18 | 20.5 | 20 mmø-15 mmø | 28 | 14 | 0.0000209817 | 27 | 15 | REHAU Kugelhahn mit AG, SDR 11 20 - R 3/4 | 4007360195182 | 12331531001 | https://oxomi.com/p/3000126/datasheet/-/12331531001 | 0.267
1093406 | no | 14 | 20 | 25 | 17.5 | 8.75 | 14 | 38 | 17 | 23 | 31.5 | 25 mmø-20 mmø | 35 | 17.5 | 0.0000597823 | 28.6 | 17.8 | REHAU Kugelhahn mit AG, SDR 11 25 - R 1 | 4059757532612 | 11601721001 | https://oxomi.com/p/3000126/datasheet/-/11601721001 | 0.344
1093486 | yes | 8 | 25 | 25 | 20 | 10 | 20 | 41.8 | 22.2 | 23 | 28 | 25 mmø-25 mmø | 35 | 17.5 | 0.0000759818 | 37 | 20 | REHAU Kugelhahn mit AG, SDR 11 32 - R 1 | 4059757518197 | 11601921001 | https://oxomi.com/p/3000126/datasheet/-/11601921001 | 0.466

# IfcPipeFitting: Ball valve SDR11:BV SDR11 LX (6)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Ball valve SDR11; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Ball valve SDR11; T2: Ball valve SDR11 DN1+DN2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.31-419114-419114; Type Name: BV SDR11 LX
Type - Materials and Finishes - Mat. Coupling: Brass gold
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Ball valve SDR11:BV SDR11 LX; sets with these values: 2
Other - IsCustom: no; Sleeve DN1: Sleeve : LX 11; Sleeve DN2: Sleeve : LX 11; A: 45 deg; V1: yes; V2: no; Type 0: yes; Type 1: no; Family: Ball valve SDR11; Family and Type: Ball valve SDR11: BV SDR11 LX; Type: BV SDR11 LX; Type Id: 1058378
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025; Tender text: Toepassing: - for pipes RAUTHERMEX SDR 11, RAUVITHERM, INSULPEX SDR 11 - for pipes RAUGEO collect, RAUGEO collect plus - for industrial pipes RAUPEX SDR 11, RAUFRIGO FW, RAUTHERM FW SDR 11 Materiaal: - Body: dezincification resistant special brass according to EN 12164 to EN 12168 - sealing: PTFE - ball: chrome-plated brass - hand lever: galvanised steel, plastic coated
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Ball valve SDR11:BV SDR11 LX:...) | C (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | HD2 (mm) | HD2/2 (mm) | HD4 (mm) | HD5 (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | SLW (mm) | SLW/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Product URL | Weight
1098981 | 5 | 15 | 15 | 7.5 | 12 | 30.7 | 13.6 | 15 mmø-15 mmø | 26 | 13 | 0.0000311486 | 27 | 34 | REHAU Kugelhahn, SDR 11 20 - 20 | 4061264785610 | 11601421001 | https://oxomi.com/p/3000126/datasheet/-/11601421001 | 0.21
1099157 | 5 | 20 | 17.5 | 8.75 | 14 | 37.5 | 17 | 20 mmø-20 mmø | 31 | 15.5 | 0.0000492797 | 28.5 | 36.5 | REHAU Kugelhahn, SDR 11 25 - 25 | 4059757518159 | 11601621001 | https://oxomi.com/p/3000126/datasheet/-/11601621001 | 0.344
1099227 | 8 | 25 | 9.5 | 4.75 | 10 | 42.3 | 22 | 25 mmø-25 mmø | 40 | 20 | 0.000079493 | 37 | 43 | REHAU Kugelhahn, SDR 11 32 - 32 | 4061264785627 | 11601821001 | https://oxomi.com/p/3000126/datasheet/-/11601821001 | 0.553
1099295 | 8 | 32 | 17 | 8.5 | 15.9 | 44 | 27 | 32 mmø-32 mmø | 50 | 25 | 0.000140053 | 39 | 45 | REHAU Kugelhahn, SDR 11 40 - 40 | 4061264785634 | 11602021001 | https://oxomi.com/p/3000126/datasheet/-/11602021001 | 0.998
1099367 | 8 | 40 | 25 | 12.5 | 25 | 58.3 | 35 | 40 mmø-40 mmø | 54 | 27 | 0.000212952 | 44.5 | 50 | REHAU Kugelhahn, SDR 11 50 - 50 | 4061264785641 | 11602121001 | https://oxomi.com/p/3000126/datasheet/-/11602121001 | 1.597
1099449 | 8 | 50 | 15.5 | 7.75 | 26 | 66.3 | 45.5 | 50 mmø-50 mmø | 75 | 37.5 | 0.000362669 | 58 | 64.2 | REHAU Kugelhahn, SDR 11 63 - 63 | 4059757518173 | 11602221001 | https://oxomi.com/p/3000126/datasheet/-/11602221001 | 2.815

# IfcPipeFitting: Coupling transistion:C RE SDR11 LX (7)
In: Level 1
Type - Material: Brass gold
Type - Other - Category: Pipe Fittings; Family Name: Coupling transistion; Max sleeve: 50 mm; Sleeve LX: Sleeve : LX 11; Sleeve RX: Sleeve : RX 11; T1: Coupling transistion; T2: Coupling transistion DN1+DN2; T3: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Language Tender Text: Tender Text de; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2090800; Description: LX11; Manufacturer: REHAU; Model: RAUPEX; REHAU Info: 2025.03.27-419114-419114; Type Name: C RE SDR11 LX; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - Mat. coupling: Brass gold
